Properties of the parts of a building model (IFC4), part 12 of 21

# IfcDistributionPort (13044)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_1116973_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 27
Port_1116985_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 27
Port_1116975_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 27
Port_1116977_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 27
Port_1116975_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 27
Port_1116981_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 27
Port_1116979_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 27
Port_1116981_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 27
Port_1116979_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 27
Port_1116987_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 27
Port_1116983_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 27
Port_1116985_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 27
Port_1116983_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 27
Port_1116987_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 27
Port_1116989_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 21
Port_1117001_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 21
Port_1116991_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 21
Port_1116993_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 21
Port_1116991_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 21
Port_1116997_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 21
Port_1116995_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 21
Port_1116997_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 21
Port_1116995_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 21
Port_1117003_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 21
Port_1116999_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 21
Port_1117001_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 21
Port_1116999_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 21
Port_1117003_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 21
Port_1117005_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117009_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117005_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117046_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117007_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117052_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117007_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117023_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117009_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117048_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117011_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117021_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117011_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117023_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117013_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117021_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117013_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117017_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117015_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117017_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117015_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117019_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117025_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117068_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117025_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117036_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117027_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117036_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117027_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117029_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117029_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117034_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117031_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117033_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117031_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117033_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117034_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117036_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117038_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117038_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117040_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117042_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117068_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117042_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117070_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117044_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117046_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117044_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117070_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117048_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117060_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117050_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117052_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117050_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117056_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117054_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117056_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117054_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117062_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117058_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117060_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117058_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117062_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 30
Port_1117072_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117074_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117072_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117078_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117074_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117718_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117076_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117208_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117076_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117210_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117078_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117081_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117080_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117081_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117080_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117210_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117080_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117093_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117084_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117098_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117084_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117088_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117086_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117102_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117086_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117192_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117088_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117106_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117088_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117103_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117090_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117788_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117090_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117790_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117092_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117093_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117092_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117098_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117092_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117790_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117096_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117192_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117096_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117194_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117100_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117190_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117100_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117102_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117102_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117103_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117106_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117116_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117108_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117116_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117108_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117112_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117110_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117112_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117110_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117150_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117112_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117114_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117114_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117124_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117116_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117118_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117118_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117122_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117120_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117122_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117120_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117164_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117124_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117134_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117126_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117136_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117126_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117130_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117128_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117130_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117128_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117132_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117134_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117136_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117138_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117150_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117138_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117144_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117140_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117144_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117140_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117142_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117144_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117146_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117146_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117148_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117152_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117164_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117152_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117158_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117154_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117158_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117154_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117156_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117158_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117160_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117160_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117162_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117166_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117172_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117166_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117190_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117168_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117172_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117168_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117170_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117172_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117174_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117174_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117176_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117178_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117184_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117178_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117194_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117180_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117184_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117180_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117182_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117184_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117186_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117186_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117188_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117196_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117202_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117196_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117208_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117198_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117202_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117198_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117200_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117202_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117204_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117204_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117206_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117212_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117216_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117212_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117786_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117214_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117216_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117214_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117224_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117216_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117218_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117218_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117220_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117222_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117224_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117222_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117226_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117226_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117227_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117227_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117229_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117233_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117229_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117728_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117231_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117233_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117231_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117237_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117235_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117363_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117235_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117365_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117237_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117240_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117239_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117240_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117239_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117365_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117239_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117252_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117243_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117257_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117243_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117247_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117245_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117247_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117245_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117347_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117247_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117389_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117249_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117794_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117249_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117384_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117251_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117252_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117251_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117257_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117251_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117384_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117255_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117347_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117255_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117349_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117259_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117345_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117259_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117392_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117261_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117388_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117261_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117271_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117263_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117271_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117263_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117267_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117265_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117267_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117265_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117305_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117267_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117269_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117269_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117279_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117271_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117273_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117273_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117277_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117275_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117277_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117275_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117319_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117279_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117289_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117281_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117291_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117281_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117285_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117283_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117285_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117283_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117287_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117289_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117291_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117293_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117305_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117293_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117299_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117295_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117299_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117295_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117297_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117299_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117301_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117301_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117303_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117307_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117319_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117307_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117313_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117309_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117313_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117309_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117311_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117313_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117315_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117315_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117317_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117321_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117327_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117321_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117345_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117323_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117327_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117323_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117325_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117327_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117329_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117329_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117331_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117333_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117339_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117333_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117349_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117335_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117339_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117335_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117337_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117339_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117341_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117341_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117343_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117351_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117357_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117351_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117363_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117353_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117357_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117353_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117355_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117357_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117359_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117359_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117361_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117367_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117371_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117367_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117796_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117369_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117371_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117369_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117379_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117371_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117373_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117373_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117375_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117377_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117379_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117377_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117381_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117381_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117382_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117382_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117386_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117388_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117386_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117392_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117388_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117389_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117394_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117398_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117394_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117730_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117396_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117398_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117396_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117402_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117400_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117532_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117400_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117534_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117402_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117405_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117404_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117405_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117404_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117534_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117404_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117417_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117408_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117422_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117408_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117412_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117410_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117426_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117410_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117516_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117412_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117430_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117412_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117427_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117414_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117800_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117414_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117553_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117416_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117417_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117416_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117422_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117416_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117553_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117420_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117516_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117420_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117518_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117424_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117514_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117424_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117426_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117426_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117427_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117430_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117440_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117432_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117440_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117432_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117436_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117434_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117436_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117434_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117474_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117436_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117438_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117438_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117448_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117440_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117442_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117442_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117446_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117444_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117446_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117444_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117488_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117448_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117458_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117450_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117460_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117450_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117454_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117452_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117454_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117452_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117456_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117458_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117460_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117462_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117474_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117462_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117468_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117464_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117468_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117464_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117466_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117468_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117470_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117470_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117472_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117476_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117488_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117476_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117482_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117478_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117482_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117478_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117480_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117482_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117484_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117484_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117486_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117490_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117496_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117490_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117514_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117492_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117496_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117492_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117494_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117496_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117498_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117498_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117500_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117502_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117508_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117502_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117518_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117504_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117508_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117504_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117506_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117508_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117510_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117510_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117512_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117520_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117526_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117520_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117532_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117522_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117526_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117522_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117524_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117526_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117528_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117528_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117530_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117536_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117540_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117536_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117802_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117538_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117540_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117538_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117548_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117540_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117542_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117542_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117544_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117546_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117548_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117546_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117550_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117550_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117551_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117551_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117555_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117559_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117555_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117734_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117557_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117559_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117557_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117563_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117561_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117689_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117561_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117691_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117563_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117566_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117565_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117566_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117565_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117691_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117565_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117578_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117569_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117583_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117569_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117573_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117571_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117573_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117571_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117673_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117573_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117713_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117575_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117780_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117575_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117782_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117577_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117578_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117577_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117583_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117577_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117782_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117581_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117673_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117581_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117675_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117585_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117671_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117585_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117716_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117587_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117712_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117587_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117597_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117589_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117597_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117589_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117593_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117591_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117593_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117591_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117631_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117593_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117595_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117595_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117605_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117597_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117599_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117599_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117603_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117601_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117603_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117601_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117645_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117605_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117615_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117607_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117617_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117607_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117611_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117609_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117611_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117609_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117613_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117615_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117617_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117619_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117631_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117619_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117625_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117621_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117625_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117621_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117623_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117625_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117627_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117627_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117629_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117633_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117645_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117633_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117639_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117635_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117639_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117635_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117637_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117639_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117641_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117641_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117643_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117647_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117653_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117647_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117671_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117649_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117653_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117649_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117651_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117653_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117655_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117655_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117657_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117659_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117665_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117659_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117675_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117661_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117665_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117661_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117663_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117665_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117667_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117667_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117669_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117677_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117683_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117677_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117689_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117679_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117683_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117679_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117681_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117683_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117685_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117685_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117687_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117693_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117697_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117693_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117778_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117695_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117697_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117695_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117705_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117697_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117699_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117699_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117701_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117703_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117705_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117703_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117707_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117707_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117708_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117708_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117710_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117712_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117710_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117716_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117712_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117713_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117718_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117722_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117720_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117722_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117720_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117754_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117724_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117730_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117724_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117770_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117726_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117728_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117726_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117762_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117732_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117734_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117732_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117738_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117736_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117738_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117736_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117742_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117740_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117742_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117740_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117746_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117744_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117746_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117744_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117750_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117748_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117750_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117748_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117752_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117754_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117752_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117758_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117756_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117758_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117756_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117760_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117762_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117760_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117766_3 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117764_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117766_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117764_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 16
Port_1117768_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117770_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117768_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117774_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117772_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117774_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117772_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117776_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117778_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117776_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117780_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 61
Port_1117784_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117786_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117784_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117788_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 7
Port_1117792_0 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117794_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117792_1 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117796_2 | SOURCEANDSINK | PIPE | SEWAGE | AC 16
Port_1117798_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117800_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117798_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1117802_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 43
Port_1118181_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118185_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118181_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118466_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118183_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118185_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118183_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118187_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118187_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118189_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118189_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118201_3 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118191_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118201_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118191_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118234_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118193_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118240_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118193_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118238_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118195_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118232_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118195_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118199_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118197_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118199_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118197_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118245_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118201_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118203_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118203_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118207_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118205_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118207_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118205_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118211_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118209_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118211_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118209_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118215_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118213_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118215_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118213_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118219_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118217_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118219_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118217_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118221_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118221_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118226_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118223_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118225_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118223_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118225_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118226_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118228_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118238_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118228_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118234_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118230_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118232_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118230_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118236_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118236_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118241_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118240_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118241_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118243_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118245_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118243_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118249_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118247_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118249_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118247_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118251_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 6
Port_1118257_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118261_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118257_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118622_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118259_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118261_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118259_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118263_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118263_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118265_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118265_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118277_3 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118267_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118277_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118267_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118310_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118269_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118316_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118269_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118314_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118271_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118308_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118271_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118275_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118273_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118275_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118273_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118321_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118277_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118279_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118279_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118283_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118281_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118283_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118281_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118287_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118285_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118287_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118285_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118291_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118289_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118291_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118289_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118295_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118293_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118295_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118293_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118297_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
Port_1118297_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 8
