Properties of the parts of a building model (IFC4), part 18 of 21

# IfcPipeSegment: Pipe Types:D2010-PVC.P (1097)
Name (Pipe Types:D2010-PVC.P:...) | In | InvertElevation (m) | Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Group
1114186 | Nivel 3 | 4.67296 | 0.714838 | 0.000357613 | 0.0479238 | AF 19
1114188 | Nivel 3 | 5.3917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 19
1114194 | Nivel 3 | 5.4122 | 0.216278 | 0.000357613 | 0.0144996 | AF 19
1114204 | Nivel 3 | 4.67296 | 0.614838 | 0.000357613 | 0.0412197 | AF 19
1114206 | Nivel 3 | 5.2917 | 0.0540775 | 0.000357613 | 0.00362544 | AF 19
1114212 | Nivel 3 | 5.3122 | 0.216278 | 0.000357613 | 0.0144996 | AF 19
1114220 | Nivel 3 | 4.67296 | 1.01484 | 0.000357613 | 0.0680363 | AF 19
1114222 | Nivel 3 | 5.6917 | 0.0760338 | 0.000357613 | 0.00509742 | AF 19
1114226 | Nivel 3 | 5.7122 | 0.191278 | 0.000357613 | 0.0128235 | AF 19
1114230 | Nivel 3 | 5.71304 | 0.0554562 | 0.000357613 | 0.00371788 | AF 19
1114235 | Nivel 3 | 5.8315 | 0.0685 | 0.000357613 | 0.00459235 | AF 19
1114239 | Nivel 3 | 4.65162 | 0.241519 | 0.000357613 | 0.0161918 | AF 19
1114242 | Nivel 3 | 4.65162 | 0.0765385 | 0.000357613 | 0.00513126 | AF 19
1114247 | Nivel 3 | 4.64964 | 0.613703 | 0.000558561 | 0.0514198 | AF 34
1114249 | Nivel 3 | 4.64964 | 1.73606 | 0.000558561 | 0.145458 | AF 34
1114253 | Nivel 3 | 4.65224 | 0.878034 | 0.000357613 | 0.0588648 | AF 34
1114258 | Nivel 3 | 4.64964 | 0.818204 | 0.000558561 | 0.0685543 | AF 34
1114261 | Nivel 3 | 4.65224 | 0.727325 | 0.000357613 | 0.048761 | AF 34
1114263 | Nivel 3 | 4.65224 | 0.494691 | 0.000357613 | 0.0331649 | AF 34
1114267 | Nivel 3 | 4.65224 | 0.437444 | 0.000357613 | 0.0293269 | AF 34
1114270 | Nivel 3 | 4.64964 | 1.6314 | 0.000558561 | 0.136689 | AF 34
1114273 | Nivel 3 | 4.65224 | 0.313599 | 0.000357613 | 0.0210242 | AF 34
1114277 | Nivel 3 | 4.65224 | 0.315695 | 0.000357613 | 0.0211647 | AF 34
1114280 | Nivel 3 | 4.65224 | 0.0998154 | 0.000357613 | 0.00669178 | AF 34
1114283 | Nivel 3 | 4.65224 | 0.876288 | 0.000357613 | 0.0587478 | AF 34
1114285 | Nivel 3 | 4.65224 | 1.0456 | 0.000357613 | 0.0700987 | AF 34
1114287 | Nivel 3 | 4.65224 | 0.483762 | 0.000357613 | 0.0324322 | AF 34
1114291 | Nivel 3 | 4.65224 | 0.753174 | 0.000357613 | 0.050494 | AF 34
1114295 | Nivel 3 | 4.65224 | 0.146956 | 0.000357613 | 0.00985218 | AF 34
1114297 | Nivel 3 | 4.65224 | 0.486997 | 0.000357613 | 0.0326491 | AF 34
1114303 | Nivel 3 | 4.67359 | 1.11337 | 0.000357613 | 0.074642 | AF 34
1114305 | Nivel 3 | 5.7917 | 0.0776598 | 0.000357613 | 0.00520644 | AF 34
1114311 | Nivel 3 | 4.65224 | 0.736455 | 0.000357613 | 0.0493731 | AF 34
1114315 | Nivel 3 | 4.67359 | 0.264213 | 0.000357613 | 0.0177132 | AF 34
1114317 | Nivel 3 | 4.9417 | 0.0690775 | 0.000357613 | 0.00463107 | AF 34
1114323 | Nivel 3 | 4.9622 | 0.216278 | 0.000357613 | 0.0144996 | AF 34
1114329 | Nivel 3 | 4.67359 | 0.516813 | 0.000357613 | 0.0346479 | AF 34
1114331 | Nivel 3 | 5.1943 | 0.0640775 | 0.000357613 | 0.00429586 | AF 34
1114337 | Nivel 3 | 5.2148 | 0.216278 | 0.000357613 | 0.0144996 | AF 34
1114343 | Nivel 3 | 4.67359 | 0.914213 | 0.000357613 | 0.0612903 | AF 34
1114345 | Nivel 3 | 5.5917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 34
1114351 | Nivel 3 | 5.6122 | 0.216278 | 0.000357613 | 0.0144996 | AF 34
1114355 | Nivel 3 | 4.67359 | 0.714213 | 0.000357613 | 0.0478819 | AF 34
1114357 | Nivel 3 | 5.3917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 34
1114363 | Nivel 3 | 5.4122 | 0.216278 | 0.000357613 | 0.0144996 | AF 34
1114373 | Nivel 3 | 4.67359 | 0.614213 | 0.000357613 | 0.0411778 | AF 34
1114375 | Nivel 3 | 5.2917 | 0.0540775 | 0.000357613 | 0.00362544 | AF 34
1114381 | Nivel 3 | 5.3122 | 0.216278 | 0.000357613 | 0.0144996 | AF 34
1114389 | Nivel 3 | 4.67359 | 1.01421 | 0.000357613 | 0.0679944 | AF 34
1114391 | Nivel 3 | 5.6917 | 0.0760338 | 0.000357613 | 0.00509742 | AF 34
1114395 | Nivel 3 | 5.7122 | 0.191278 | 0.000357613 | 0.0128235 | AF 34
1114399 | Nivel 3 | 5.71304 | 0.0554563 | 0.000357613 | 0.00371788 | AF 34
1114404 | Nivel 3 | 5.8315 | 0.0685 | 0.000357613 | 0.00459235 | AF 34
1114408 | Nivel 3 | 4.6492 | 1.2056 | 0.000558561 | 0.101013 | AF 49
1114410 | Nivel 3 | 4.6492 | 1.96111 | 0.000558561 | 0.164314 | AF 49
1114414 | Nivel 3 | 4.65181 | 0.76386 | 0.000357613 | 0.0512104 | AF 49
1114419 | Nivel 3 | 4.6492 | 0.932378 | 0.000558561 | 0.0781205 | AF 49
1114422 | Nivel 3 | 4.65181 | 0.624182 | 0.000357613 | 0.0418461 | AF 49
1114424 | Nivel 3 | 4.65181 | 0.504732 | 0.000357613 | 0.0338381 | AF 49
1114428 | Nivel 3 | 4.65181 | 0.53327 | 0.000357613 | 0.0357512 | AF 49
1114431 | Nivel 3 | 4.6492 | 1.50954 | 0.000558561 | 0.126479 | AF 49
1114434 | Nivel 3 | 4.65181 | 0.313599 | 0.000357613 | 0.0210242 | AF 49
1114438 | Nivel 3 | 4.65181 | 0.213913 | 0.000357613 | 0.014341 | AF 49
1114440 | Nivel 3 | 4.65181 | 0.77535 | 0.000357613 | 0.0519807 | AF 49
1114442 | Nivel 3 | 4.65181 | 0.706569 | 0.000357613 | 0.0473695 | AF 49
1114444 | Nivel 3 | 4.65181 | 0.483762 | 0.000357613 | 0.0324322 | AF 49
1114448 | Nivel 3 | 4.65181 | 0.754811 | 0.000357613 | 0.0506038 | AF 49
1114452 | Nivel 3 | 4.65181 | 0.119303 | 0.000357613 | 0.00799829 | AF 49
1114454 | Nivel 3 | 4.65181 | 0.486997 | 0.000357613 | 0.0326491 | AF 49
1114460 | Nivel 3 | 4.67315 | 1.11381 | 0.000357613 | 0.0746713 | AF 49
1114462 | Nivel 3 | 5.7917 | 0.0776598 | 0.000357613 | 0.00520644 | AF 49
1114468 | Nivel 3 | 4.65181 | 0.736455 | 0.000357613 | 0.0493731 | AF 49
1114472 | Nivel 3 | 4.67315 | 0.264649 | 0.000357613 | 0.0177425 | AF 49
1114474 | Nivel 3 | 4.9417 | 0.0690775 | 0.000357613 | 0.00463107 | AF 49
1114480 | Nivel 3 | 4.9622 | 0.216278 | 0.000357613 | 0.0144996 | AF 49
1114486 | Nivel 3 | 4.67315 | 0.517249 | 0.000357613 | 0.0346772 | AF 49
1114488 | Nivel 3 | 5.1943 | 0.0640775 | 0.000357613 | 0.00429586 | AF 49
1114494 | Nivel 3 | 5.2148 | 0.216278 | 0.000357613 | 0.0144996 | AF 49
1114500 | Nivel 3 | 4.67315 | 0.914646 | 0.000357613 | 0.0613193 | AF 49
1114502 | Nivel 3 | 5.5917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 49
1114508 | Nivel 3 | 5.6122 | 0.216278 | 0.000357613 | 0.0144996 | AF 49
1114512 | Nivel 3 | 4.67315 | 0.714649 | 0.000357613 | 0.0479112 | AF 49
1114514 | Nivel 3 | 5.3917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 49
1114520 | Nivel 3 | 5.4122 | 0.216278 | 0.000357613 | 0.0144996 | AF 49
1114530 | Nivel 3 | 4.67315 | 0.614649 | 0.000357613 | 0.041207 | AF 49
1114532 | Nivel 3 | 5.2917 | 0.0540775 | 0.000357613 | 0.00362544 | AF 49
1114538 | Nivel 3 | 5.3122 | 0.216278 | 0.000357613 | 0.0144996 | AF 49
1114546 | Nivel 3 | 4.67315 | 1.01465 | 0.000357613 | 0.0680237 | AF 49
1114548 | Nivel 3 | 5.6917 | 0.0760338 | 0.000357613 | 0.00509742 | AF 49
1114552 | Nivel 3 | 5.7122 | 0.191278 | 0.000357613 | 0.0128235 | AF 49
1114556 | Nivel 3 | 5.71304 | 0.0554562 | 0.000357613 | 0.00371788 | AF 49
1114561 | Nivel 3 | 5.8315 | 0.0685 | 0.000357613 | 0.00459235 | AF 49
1114563 | Nivel 3 | 4.65181 | 0.231602 | 0.000357613 | 0.015527 | AF 49
1114566 | Nivel 3 | 4.65181 | 0.0765385 | 0.000357613 | 0.00513126 | AF 49
1114571 | Nivel 3 | 4.649 | 5.2737 | 0.000558561 | 0.441864 | AF 4
1114573 | Nivel 3 | 4.64899 | 1.86525 | 0.000558561 | 0.156282 | AF 4
1114577 | Nivel 3 | 4.64964 | 0.394811 | 0.000558561 | 0.0330798 | AF 34
1114579 | Nivel 3 | 4.64901 | 1.8751 | 0.000558561 | 0.157108 | AF 19
1114585 | Nivel 3 | 4.6492 | 1.3887 | 0.000558561 | 0.116354 | AF 49
1114589 | Nivel 3 | 4.6492 | 3.9937 | 0.000558561 | 0.334617 | AF 49
1114593 | Nivel 3 | 4.6492 | 1.81486 | 0.000558561 | 0.152061 | AF 49
1114597 | Nivel 3 | 4.67575 | 0.378703 | 0.000558561 | 0.0317301 | AF 49
1114601 | Nivel 3 | 5.0592 | 0.0812029 | 0.000558561 | 0.00680369 | AF 49
1114605 | Nivel 3 | 4.67555 | 0.543703 | 0.000558561 | 0.0455548 | AF 4
1114609 | Nivel 3 | 5.22399 | 0.124301 | 0.000558561 | 0.0104147 | AF 4
1114613 | Nivel 3 | 4.67557 | 0.723703 | 0.000558561 | 0.0606363 | AF 19
1114617 | Nivel 3 | 5.40401 | 0.169301 | 0.000558561 | 0.0141851 | AF 19
1114621 | Nivel 3 | 4.67619 | 0.873703 | 0.000558561 | 0.0732043 | AF 34
1114625 | Nivel 3 | 5.55464 | 0.209301 | 0.000558561 | 0.0175366 | AF 34
1114629 | Nivel 3 | 4.65181 | 0.348258 | 0.000357613 | 0.0233478 | AF 49
1114637 | Nivel 3 | 4.65162 | 0.380945 | 0.000357613 | 0.0255392 | AF 4
1114645 | Nivel 3 | 4.65162 | 0.408258 | 0.000357613 | 0.0273703 | AF 19
1114651 | Nivel 3 | 4.65224 | 0.245114 | 0.000357613 | 0.0164329 | AF 34
1114978 | Nivel 4 | 6.999 | 1.74591 | 0.000558561 | 0.146283 | AF 5
1114982 | Nivel 4 | 7.00162 | 0.873034 | 0.000357613 | 0.0585296 | AF 5
1114987 | Nivel 4 | 6.99901 | 0.823204 | 0.000558561 | 0.0689732 | AF 5
1114990 | Nivel 4 | 7.00162 | 0.591494 | 0.000357613 | 0.0396547 | AF 5
1114992 | Nivel 4 | 7.00162 | 0.380489 | 0.000357613 | 0.0255086 | AF 5
1114996 | Nivel 4 | 7.00162 | 0.468669 | 0.000357613 | 0.0314203 | AF 5
1114999 | Nivel 4 | 6.99901 | 1.76723 | 0.000558561 | 0.148069 | AF 5
1115002 | Nivel 4 | 7.00162 | 0.313599 | 0.000357613 | 0.0210242 | AF 5
1115006 | Nivel 4 | 7.00162 | 0.315695 | 0.000357613 | 0.0211647 | AF 5
1115009 | Nivel 4 | 7.00162 | 0.209017 | 0.000357613 | 0.0140129 | AF 5
1115012 | Nivel 4 | 7.00162 | 0.876288 | 0.000357613 | 0.0587478 | AF 5
1115014 | Nivel 4 | 7.00162 | 1.0406 | 0.000357613 | 0.0697635 | AF 5
1115016 | Nivel 4 | 7.00162 | 0.483762 | 0.000357613 | 0.0324322 | AF 5
1115020 | Nivel 4 | 7.00162 | 0.753174 | 0.000357613 | 0.050494 | AF 5
1115024 | Nivel 4 | 7.00162 | 0.151956 | 0.000357613 | 0.0101874 | AF 5
1115026 | Nivel 4 | 7.00162 | 0.486997 | 0.000357613 | 0.0326491 | AF 5
1115032 | Nivel 4 | 7.02296 | 1.11399 | 0.000357613 | 0.0746839 | AF 5
1115034 | Nivel 4 | 8.1417 | 0.0776598 | 0.000357613 | 0.00520644 | AF 5
1115040 | Nivel 4 | 7.00162 | 0.736455 | 0.000357613 | 0.0493731 | AF 5
1115044 | Nivel 4 | 7.02296 | 0.264838 | 0.000357613 | 0.0177551 | AF 5
1115046 | Nivel 4 | 7.2917 | 0.0690775 | 0.000357613 | 0.00463107 | AF 5
1115052 | Nivel 4 | 7.3122 | 0.216278 | 0.000357613 | 0.0144996 | AF 5
1115058 | Nivel 4 | 7.02296 | 0.517438 | 0.000357613 | 0.0346898 | AF 5
1115060 | Nivel 4 | 7.5443 | 0.0640775 | 0.000357613 | 0.00429586 | AF 5
1115066 | Nivel 4 | 7.5648 | 0.216278 | 0.000357613 | 0.0144996 | AF 5
1115072 | Nivel 4 | 7.02296 | 0.914838 | 0.000357613 | 0.0613322 | AF 5
1115074 | Nivel 4 | 7.9417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 5
1115080 | Nivel 4 | 7.9622 | 0.216278 | 0.000357613 | 0.0144996 | AF 5
1115084 | Nivel 4 | 7.02296 | 0.714838 | 0.000357613 | 0.0479238 | AF 5
1115086 | Nivel 4 | 7.7417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 5
1115092 | Nivel 4 | 7.7622 | 0.216278 | 0.000357613 | 0.0144996 | AF 5
1115102 | Nivel 4 | 7.02296 | 0.614838 | 0.000357613 | 0.0412197 | AF 5
1115104 | Nivel 4 | 7.6417 | 0.0540775 | 0.000357613 | 0.00362544 | AF 5
1115110 | Nivel 4 | 7.6622 | 0.216278 | 0.000357613 | 0.0144996 | AF 5
1115118 | Nivel 4 | 7.02296 | 1.01484 | 0.000357613 | 0.0680363 | AF 5
1115120 | Nivel 4 | 8.0417 | 0.0760338 | 0.000357613 | 0.00509742 | AF 5
1115124 | Nivel 4 | 8.0622 | 0.191278 | 0.000357613 | 0.0128235 | AF 5
1115128 | Nivel 4 | 8.06304 | 0.0554563 | 0.000357613 | 0.00371788 | AF 5
1115133 | Nivel 4 | 8.1815 | 0.0685 | 0.000357613 | 0.00459235 | AF 5
1115135 | Nivel 4 | 6.99901 | 0.653703 | 0.000558561 | 0.0547713 | AF 21
1115137 | Nivel 4 | 6.99901 | 1.96106 | 0.000558561 | 0.16431 | AF 21
1115141 | Nivel 4 | 7.00162 | 0.75842 | 0.000357613 | 0.0508457 | AF 21
1115146 | Nivel 4 | 6.99901 | 0.937817 | 0.000558561 | 0.0785762 | AF 21
1115149 | Nivel 4 | 7.00162 | 0.564182 | 0.000357613 | 0.0378236 | AF 21
1115151 | Nivel 4 | 7.00162 | 0.499293 | 0.000357613 | 0.0334734 | AF 21
1115155 | Nivel 4 | 7.00162 | 0.529611 | 0.000357613 | 0.0355059 | AF 21
1115158 | Nivel 4 | 6.99901 | 1.56954 | 0.000558561 | 0.131506 | AF 21
1115161 | Nivel 4 | 7.00162 | 0.313599 | 0.000357613 | 0.0210242 | AF 21
1115165 | Nivel 4 | 7.00162 | 0.213913 | 0.000357613 | 0.014341 | AF 21
1115167 | Nivel 4 | 7.00162 | 0.77535 | 0.000357613 | 0.0519807 | AF 21
1115169 | Nivel 4 | 7.00162 | 0.664404 | 0.000357613 | 0.0445427 | AF 21
1115171 | Nivel 4 | 7.00162 | 0.483762 | 0.000357613 | 0.0324322 | AF 21
1115175 | Nivel 4 | 7.00162 | 0.791537 | 0.000357613 | 0.0530659 | AF 21
1115179 | Nivel 4 | 7.00162 | 0.0618916 | 0.000357613 | 0.00414931 | AF 21
1115181 | Nivel 4 | 7.00162 | 0.486997 | 0.000357613 | 0.0326491 | AF 21
1115187 | Nivel 4 | 7.02296 | 1.11399 | 0.000357613 | 0.0746839 | AF 21
1115189 | Nivel 4 | 8.1417 | 0.0776598 | 0.000357613 | 0.00520644 | AF 21
1115195 | Nivel 4 | 7.00162 | 0.736455 | 0.000357613 | 0.0493731 | AF 21
1115199 | Nivel 4 | 7.02296 | 0.264838 | 0.000357613 | 0.0177551 | AF 21
1115201 | Nivel 4 | 7.2917 | 0.0690775 | 0.000357613 | 0.00463107 | AF 21
1115207 | Nivel 4 | 7.3122 | 0.216278 | 0.000357613 | 0.0144996 | AF 21
1115213 | Nivel 4 | 7.02296 | 0.517438 | 0.000357613 | 0.0346898 | AF 21
1115215 | Nivel 4 | 7.5443 | 0.0640775 | 0.000357613 | 0.00429586 | AF 21
1115221 | Nivel 4 | 7.5648 | 0.216278 | 0.000357613 | 0.0144996 | AF 21
1115227 | Nivel 4 | 7.02296 | 0.914838 | 0.000357613 | 0.0613322 | AF 21
1115229 | Nivel 4 | 7.9417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 21
1115235 | Nivel 4 | 7.9622 | 0.216278 | 0.000357613 | 0.0144996 | AF 21
1115239 | Nivel 4 | 7.02296 | 0.714838 | 0.000357613 | 0.0479238 | AF 21
1115241 | Nivel 4 | 7.7417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 21
1115247 | Nivel 4 | 7.7622 | 0.216278 | 0.000357613 | 0.0144996 | AF 21
1115257 | Nivel 4 | 7.02296 | 0.614838 | 0.000357613 | 0.0412197 | AF 21
1115259 | Nivel 4 | 7.6417 | 0.0540775 | 0.000357613 | 0.00362544 | AF 21
1115265 | Nivel 4 | 7.6622 | 0.216278 | 0.000357613 | 0.0144996 | AF 21
1115273 | Nivel 4 | 7.02296 | 1.01484 | 0.000357613 | 0.0680363 | AF 21
1115275 | Nivel 4 | 8.0417 | 0.0760338 | 0.000357613 | 0.00509742 | AF 21
1115279 | Nivel 4 | 8.0622 | 0.191278 | 0.000357613 | 0.0128235 | AF 21
1115283 | Nivel 4 | 8.06304 | 0.0554562 | 0.000357613 | 0.00371788 | AF 21
1115288 | Nivel 4 | 8.1815 | 0.0685 | 0.000357613 | 0.00459235 | AF 21
1115292 | Nivel 4 | 7.00162 | 0.241519 | 0.000357613 | 0.0161918 | AF 21
1115295 | Nivel 4 | 7.00162 | 0.0765385 | 0.000357613 | 0.00513126 | AF 21
1115300 | Nivel 4 | 6.99964 | 0.613703 | 0.000558561 | 0.0514198 | AF 37
1115302 | Nivel 4 | 6.99964 | 1.73606 | 0.000558561 | 0.145458 | AF 37
1115306 | Nivel 4 | 7.00224 | 0.868034 | 0.000357613 | 0.0581943 | AF 37
1115311 | Nivel 4 | 6.99964 | 0.828204 | 0.000558561 | 0.0693921 | AF 37
1115314 | Nivel 4 | 7.00224 | 0.727325 | 0.000357613 | 0.048761 | AF 37
1115316 | Nivel 4 | 7.00224 | 0.494691 | 0.000357613 | 0.0331649 | AF 37
1115320 | Nivel 4 | 7.00224 | 0.427444 | 0.000357613 | 0.0286565 | AF 37
1115323 | Nivel 4 | 6.99964 | 1.6314 | 0.000558561 | 0.136689 | AF 37
1115326 | Nivel 4 | 7.00224 | 0.313599 | 0.000357613 | 0.0210242 | AF 37
1115330 | Nivel 4 | 7.00224 | 0.315695 | 0.000357613 | 0.0211647 | AF 37
1115333 | Nivel 4 | 7.00224 | 0.0898154 | 0.000357613 | 0.00602136 | AF 37
1115336 | Nivel 4 | 7.00224 | 0.876288 | 0.000357613 | 0.0587478 | AF 37
1115338 | Nivel 4 | 7.00224 | 1.0356 | 0.000357613 | 0.0694283 | AF 37
1115340 | Nivel 4 | 7.00224 | 0.483762 | 0.000357613 | 0.0324322 | AF 37
1115344 | Nivel 4 | 7.00224 | 0.753174 | 0.000357613 | 0.050494 | AF 37
1115348 | Nivel 4 | 7.00224 | 0.156956 | 0.000357613 | 0.0105226 | AF 37
1115350 | Nivel 4 | 7.00224 | 0.486997 | 0.000357613 | 0.0326491 | AF 37
1115356 | Nivel 4 | 7.02359 | 1.11337 | 0.000357613 | 0.074642 | AF 37
1115358 | Nivel 4 | 8.1417 | 0.0776598 | 0.000357613 | 0.00520644 | AF 37
1115364 | Nivel 4 | 7.00224 | 0.736455 | 0.000357613 | 0.0493731 | AF 37
1115368 | Nivel 4 | 7.02359 | 0.264213 | 0.000357613 | 0.0177132 | AF 37
1115370 | Nivel 4 | 7.2917 | 0.0690775 | 0.000357613 | 0.00463107 | AF 37
1115376 | Nivel 4 | 7.3122 | 0.216278 | 0.000357613 | 0.0144996 | AF 37
1115382 | Nivel 4 | 7.02359 | 0.516813 | 0.000357613 | 0.0346479 | AF 37
1115384 | Nivel 4 | 7.5443 | 0.0640775 | 0.000357613 | 0.00429586 | AF 37
1115390 | Nivel 4 | 7.5648 | 0.216278 | 0.000357613 | 0.0144996 | AF 37
1115396 | Nivel 4 | 7.02359 | 0.914213 | 0.000357613 | 0.0612903 | AF 37
1115398 | Nivel 4 | 7.9417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 37
1115404 | Nivel 4 | 7.9622 | 0.216278 | 0.000357613 | 0.0144996 | AF 37
1115408 | Nivel 4 | 7.02359 | 0.714213 | 0.000357613 | 0.0478819 | AF 37
1115410 | Nivel 4 | 7.7417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 37
1115416 | Nivel 4 | 7.7622 | 0.216278 | 0.000357613 | 0.0144996 | AF 37
1115426 | Nivel 4 | 7.02359 | 0.614213 | 0.000357613 | 0.0411778 | AF 37
1115428 | Nivel 4 | 7.6417 | 0.0540775 | 0.000357613 | 0.00362544 | AF 37
1115434 | Nivel 4 | 7.6622 | 0.216278 | 0.000357613 | 0.0144996 | AF 37
1115442 | Nivel 4 | 7.02359 | 1.01421 | 0.000357613 | 0.0679944 | AF 37
1115444 | Nivel 4 | 8.0417 | 0.0760338 | 0.000357613 | 0.00509742 | AF 37
1115448 | Nivel 4 | 8.0622 | 0.191278 | 0.000357613 | 0.0128235 | AF 37
1115452 | Nivel 4 | 8.06304 | 0.0554563 | 0.000357613 | 0.00371788 | AF 37
1115457 | Nivel 4 | 8.1815 | 0.0685 | 0.000357613 | 0.00459235 | AF 37
1115461 | Nivel 4 | 6.9992 | 1.2056 | 0.000558561 | 0.101013 | AF 53
1115463 | Nivel 4 | 6.9992 | 1.96111 | 0.000558561 | 0.164314 | AF 53
1115467 | Nivel 4 | 7.00181 | 0.75886 | 0.000357613 | 0.0508752 | AF 53
1115472 | Nivel 4 | 6.9992 | 0.937378 | 0.000558561 | 0.0785394 | AF 53
1115475 | Nivel 4 | 7.00181 | 0.624182 | 0.000357613 | 0.0418461 | AF 53
1115477 | Nivel 4 | 7.00181 | 0.499732 | 0.000357613 | 0.0335028 | AF 53
1115481 | Nivel 4 | 7.00181 | 0.52827 | 0.000357613 | 0.035416 | AF 53
1115484 | Nivel 4 | 6.9992 | 1.50954 | 0.000558561 | 0.126479 | AF 53
1115487 | Nivel 4 | 7.00181 | 0.313599 | 0.000357613 | 0.0210242 | AF 53
1115491 | Nivel 4 | 7.00181 | 0.213913 | 0.000357613 | 0.014341 | AF 53
1115493 | Nivel 4 | 7.00181 | 0.77535 | 0.000357613 | 0.0519807 | AF 53
1115495 | Nivel 4 | 7.00181 | 0.701569 | 0.000357613 | 0.0470343 | AF 53
1115497 | Nivel 4 | 7.00181 | 0.483762 | 0.000357613 | 0.0324322 | AF 53
1115501 | Nivel 4 | 7.00181 | 0.754811 | 0.000357613 | 0.0506038 | AF 53
1115505 | Nivel 4 | 7.00181 | 0.124303 | 0.000357613 | 0.0083335 | AF 53
1115507 | Nivel 4 | 7.00181 | 0.486997 | 0.000357613 | 0.0326491 | AF 53
1115513 | Nivel 4 | 7.02315 | 1.11381 | 0.000357613 | 0.0746713 | AF 53
1115515 | Nivel 4 | 8.1417 | 0.0776598 | 0.000357613 | 0.00520644 | AF 53
1115521 | Nivel 4 | 7.00181 | 0.736455 | 0.000357613 | 0.0493731 | AF 53
1115525 | Nivel 4 | 7.02315 | 0.264649 | 0.000357613 | 0.0177425 | AF 53
1115527 | Nivel 4 | 7.2917 | 0.0690775 | 0.000357613 | 0.00463107 | AF 53
1115533 | Nivel 4 | 7.3122 | 0.216278 | 0.000357613 | 0.0144996 | AF 53
1115539 | Nivel 4 | 7.02315 | 0.517249 | 0.000357613 | 0.0346772 | AF 53
1115541 | Nivel 4 | 7.5443 | 0.0640775 | 0.000357613 | 0.00429586 | AF 53
1115547 | Nivel 4 | 7.5648 | 0.216278 | 0.000357613 | 0.0144996 | AF 53
1115553 | Nivel 4 | 7.02315 | 0.914646 | 0.000357613 | 0.0613193 | AF 53
1115555 | Nivel 4 | 7.9417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 53
1115561 | Nivel 4 | 7.9622 | 0.216278 | 0.000357613 | 0.0144996 | AF 53
1115565 | Nivel 4 | 7.02315 | 0.714649 | 0.000357613 | 0.0479112 | AF 53
1115567 | Nivel 4 | 7.7417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 53
1115573 | Nivel 4 | 7.7622 | 0.216278 | 0.000357613 | 0.0144996 | AF 53
1115583 | Nivel 4 | 7.02315 | 0.614649 | 0.000357613 | 0.041207 | AF 53
1115585 | Nivel 4 | 7.6417 | 0.0540775 | 0.000357613 | 0.00362544 | AF 53
1115591 | Nivel 4 | 7.6622 | 0.216278 | 0.000357613 | 0.0144996 | AF 53
1115599 | Nivel 4 | 7.02315 | 1.01465 | 0.000357613 | 0.0680237 | AF 53
1115601 | Nivel 4 | 8.0417 | 0.0760338 | 0.000357613 | 0.00509742 | AF 53
1115605 | Nivel 4 | 8.0622 | 0.191278 | 0.000357613 | 0.0128235 | AF 53
1115609 | Nivel 4 | 8.06304 | 0.0554562 | 0.000357613 | 0.00371788 | AF 53
1115614 | Nivel 4 | 8.1815 | 0.0685 | 0.000357613 | 0.00459235 | AF 53
1115616 | Nivel 4 | 7.00181 | 0.236602 | 0.000357613 | 0.0158622 | AF 53
1115619 | Nivel 4 | 7.00181 | 0.0765385 | 0.000357613 | 0.00513126 | AF 53
1115624 | Nivel 4 | 6.999 | 5.2737 | 0.000558561 | 0.441864 | AF 5
1115626 | Nivel 4 | 6.99899 | 1.86525 | 0.000558561 | 0.156282 | AF 5
1115630 | Nivel 4 | 6.99964 | 0.394811 | 0.000558561 | 0.0330798 | AF 37
1115632 | Nivel 4 | 6.99901 | 1.8751 | 0.000558561 | 0.157108 | AF 21
1115638 | Nivel 4 | 6.9992 | 1.3887 | 0.000558561 | 0.116354 | AF 53
1115642 | Nivel 4 | 6.9992 | 3.9937 | 0.000558561 | 0.334617 | AF 53
1115646 | Nivel 4 | 6.9992 | 1.81486 | 0.000558561 | 0.152061 | AF 53
1115650 | Nivel 4 | 7.02575 | 0.378703 | 0.000558561 | 0.0317301 | AF 53
1115654 | Nivel 4 | 7.4092 | 0.0812029 | 0.000558561 | 0.00680369 | AF 53
1115658 | Nivel 4 | 7.02555 | 0.543703 | 0.000558561 | 0.0455548 | AF 5
1115662 | Nivel 4 | 7.57399 | 0.124301 | 0.000558561 | 0.0104147 | AF 5
1115666 | Nivel 4 | 7.02557 | 0.723703 | 0.000558561 | 0.0606363 | AF 21
1115670 | Nivel 4 | 7.75401 | 0.169301 | 0.000558561 | 0.0141851 | AF 21
1115674 | Nivel 4 | 7.02619 | 0.873703 | 0.000558561 | 0.0732043 | AF 37
1115678 | Nivel 4 | 7.90464 | 0.209301 | 0.000558561 | 0.0175366 | AF 37
1115682 | Nivel 4 | 7.00181 | 0.348258 | 0.000357613 | 0.0233478 | AF 53
1115690 | Nivel 4 | 7.00162 | 0.380945 | 0.000357613 | 0.0255392 | AF 5
1115698 | Nivel 4 | 7.00162 | 0.408258 | 0.000357613 | 0.0273703 | AF 21
1115704 | Nivel 4 | 7.00224 | 0.245114 | 0.000357613 | 0.0164329 | AF 37
1116031 | Nivel 5 | 9.349 | 1.74591 | 0.000558561 | 0.146283 | AF 6
1116035 | Nivel 5 | 9.35162 | 0.898034 | 0.000357613 | 0.0602056 | AF 6
1116040 | Nivel 5 | 9.34901 | 0.798204 | 0.000558561 | 0.0668785 | AF 6
1116043 | Nivel 5 | 9.35162 | 0.591494 | 0.000357613 | 0.0396547 | AF 6
1116045 | Nivel 5 | 9.35162 | 0.380489 | 0.000357613 | 0.0255086 | AF 6
1116049 | Nivel 5 | 9.35162 | 0.493669 | 0.000357613 | 0.0330963 | AF 6
1116052 | Nivel 5 | 9.34901 | 1.76723 | 0.000558561 | 0.148069 | AF 6
1116055 | Nivel 5 | 9.35162 | 0.313599 | 0.000357613 | 0.0210242 | AF 6
1116059 | Nivel 5 | 9.35162 | 0.315695 | 0.000357613 | 0.0211647 | AF 6
1116062 | Nivel 5 | 9.35162 | 0.234017 | 0.000357613 | 0.0156889 | AF 6
1116065 | Nivel 5 | 9.35162 | 0.876288 | 0.000357613 | 0.0587478 | AF 6
1116067 | Nivel 5 | 9.35162 | 1.0656 | 0.000357613 | 0.0714395 | AF 6
1116069 | Nivel 5 | 9.35162 | 0.483762 | 0.000357613 | 0.0324322 | AF 6
1116073 | Nivel 5 | 9.35162 | 0.753174 | 0.000357613 | 0.050494 | AF 6
1116077 | Nivel 5 | 9.35162 | 0.126956 | 0.000357613 | 0.00851135 | AF 6
1116079 | Nivel 5 | 9.35162 | 0.486997 | 0.000357613 | 0.0326491 | AF 6
1116085 | Nivel 5 | 9.37296 | 1.11399 | 0.000357613 | 0.0746839 | AF 6
1116087 | Nivel 5 | 10.4917 | 0.0776598 | 0.000357613 | 0.00520644 | AF 6
1116093 | Nivel 5 | 9.35162 | 0.736455 | 0.000357613 | 0.0493731 | AF 6
1116097 | Nivel 5 | 9.37296 | 0.264838 | 0.000357613 | 0.0177551 | AF 6
1116099 | Nivel 5 | 9.6417 | 0.0690775 | 0.000357613 | 0.00463107 | AF 6
1116105 | Nivel 5 | 9.6622 | 0.216278 | 0.000357613 | 0.0144996 | AF 6
1116111 | Nivel 5 | 9.37296 | 0.517438 | 0.000357613 | 0.0346898 | AF 6
1116113 | Nivel 5 | 9.8943 | 0.0640775 | 0.000357613 | 0.00429586 | AF 6
1116119 | Nivel 5 | 9.9148 | 0.216278 | 0.000357613 | 0.0144996 | AF 6
1116125 | Nivel 5 | 9.37296 | 0.914838 | 0.000357613 | 0.0613322 | AF 6
1116127 | Nivel 5 | 10.2917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 6
1116133 | Nivel 5 | 10.3122 | 0.216278 | 0.000357613 | 0.0144996 | AF 6
1116137 | Nivel 5 | 9.37296 | 0.714838 | 0.000357613 | 0.0479238 | AF 6
1116139 | Nivel 5 | 10.0917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 6
1116145 | Nivel 5 | 10.1122 | 0.216278 | 0.000357613 | 0.0144996 | AF 6
1116155 | Nivel 5 | 9.37296 | 0.614838 | 0.000357613 | 0.0412197 | AF 6
1116157 | Nivel 5 | 9.9917 | 0.0540775 | 0.000357613 | 0.00362544 | AF 6
1116163 | Nivel 5 | 10.0122 | 0.216278 | 0.000357613 | 0.0144996 | AF 6
1116171 | Nivel 5 | 9.37296 | 1.01484 | 0.000357613 | 0.0680363 | AF 6
1116173 | Nivel 5 | 10.3917 | 0.0760338 | 0.000357613 | 0.00509742 | AF 6
1116177 | Nivel 5 | 10.4122 | 0.191278 | 0.000357613 | 0.0128235 | AF 6
1116181 | Nivel 5 | 10.413 | 0.0554563 | 0.000357613 | 0.00371788 | AF 6
1116186 | Nivel 5 | 10.5315 | 0.0685 | 0.000357613 | 0.00459235 | AF 6
1116188 | Nivel 5 | 9.34901 | 0.653703 | 0.000558561 | 0.0547713 | AF 23
1116190 | Nivel 5 | 9.34901 | 1.96106 | 0.000558561 | 0.16431 | AF 23
1116194 | Nivel 5 | 9.35162 | 0.75842 | 0.000357613 | 0.0508457 | AF 23
1116199 | Nivel 5 | 9.34901 | 0.937817 | 0.000558561 | 0.0785762 | AF 23
1116202 | Nivel 5 | 9.35162 | 0.564182 | 0.000357613 | 0.0378236 | AF 23
1116204 | Nivel 5 | 9.35162 | 0.499293 | 0.000357613 | 0.0334734 | AF 23
1116208 | Nivel 5 | 9.35162 | 0.529611 | 0.000357613 | 0.0355059 | AF 23
1116211 | Nivel 5 | 9.34901 | 1.56954 | 0.000558561 | 0.131506 | AF 23
1116214 | Nivel 5 | 9.35162 | 0.313599 | 0.000357613 | 0.0210242 | AF 23
1116218 | Nivel 5 | 9.35162 | 0.213913 | 0.000357613 | 0.014341 | AF 23
1116220 | Nivel 5 | 9.35162 | 0.77535 | 0.000357613 | 0.0519807 | AF 23
1116222 | Nivel 5 | 9.35162 | 0.664404 | 0.000357613 | 0.0445427 | AF 23
1116224 | Nivel 5 | 9.35162 | 0.483762 | 0.000357613 | 0.0324322 | AF 23
1116228 | Nivel 5 | 9.35162 | 0.791537 | 0.000357613 | 0.0530659 | AF 23
1116232 | Nivel 5 | 9.35162 | 0.0618916 | 0.000357613 | 0.00414931 | AF 23
1116234 | Nivel 5 | 9.35162 | 0.486997 | 0.000357613 | 0.0326491 | AF 23
1116240 | Nivel 5 | 9.37296 | 1.11399 | 0.000357613 | 0.0746839 | AF 23
1116242 | Nivel 5 | 10.4917 | 0.0776598 | 0.000357613 | 0.00520644 | AF 23
1116248 | Nivel 5 | 9.35162 | 0.736455 | 0.000357613 | 0.0493731 | AF 23
1116252 | Nivel 5 | 9.37296 | 0.264838 | 0.000357613 | 0.0177551 | AF 23
1116254 | Nivel 5 | 9.6417 | 0.0690775 | 0.000357613 | 0.00463107 | AF 23
1116260 | Nivel 5 | 9.6622 | 0.216278 | 0.000357613 | 0.0144996 | AF 23
1116266 | Nivel 5 | 9.37296 | 0.517438 | 0.000357613 | 0.0346898 | AF 23
1116268 | Nivel 5 | 9.8943 | 0.0640775 | 0.000357613 | 0.00429586 | AF 23
1116274 | Nivel 5 | 9.9148 | 0.216278 | 0.000357613 | 0.0144996 | AF 23
1116280 | Nivel 5 | 9.37296 | 0.914838 | 0.000357613 | 0.0613322 | AF 23
1116282 | Nivel 5 | 10.2917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 23
1116288 | Nivel 5 | 10.3122 | 0.216278 | 0.000357613 | 0.0144996 | AF 23
1116292 | Nivel 5 | 9.37296 | 0.714838 | 0.000357613 | 0.0479238 | AF 23
1116294 | Nivel 5 | 10.0917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 23
1116300 | Nivel 5 | 10.1122 | 0.216278 | 0.000357613 | 0.0144996 | AF 23
1116310 | Nivel 5 | 9.37296 | 0.614838 | 0.000357613 | 0.0412197 | AF 23
1116312 | Nivel 5 | 9.9917 | 0.0540775 | 0.000357613 | 0.00362544 | AF 23
1116318 | Nivel 5 | 10.0122 | 0.216278 | 0.000357613 | 0.0144996 | AF 23
1116326 | Nivel 5 | 9.37296 | 1.01484 | 0.000357613 | 0.0680363 | AF 23
1116328 | Nivel 5 | 10.3917 | 0.0760338 | 0.000357613 | 0.00509742 | AF 23
1116332 | Nivel 5 | 10.4122 | 0.191278 | 0.000357613 | 0.0128235 | AF 23
1116336 | Nivel 5 | 10.413 | 0.0554562 | 0.000357613 | 0.00371788 | AF 23
1116341 | Nivel 5 | 10.5315 | 0.0685 | 0.000357613 | 0.00459235 | AF 23
1116345 | Nivel 5 | 9.35162 | 0.241519 | 0.000357613 | 0.0161918 | AF 23
1116348 | Nivel 5 | 9.35162 | 0.0765385 | 0.000357613 | 0.00513126 | AF 23
1116353 | Nivel 5 | 9.34964 | 0.613703 | 0.000558561 | 0.0514198 | AF 40
1116355 | Nivel 5 | 9.34964 | 1.73606 | 0.000558561 | 0.145458 | AF 40
1116359 | Nivel 5 | 9.35224 | 0.898034 | 0.000357613 | 0.0602056 | AF 40
1116364 | Nivel 5 | 9.34964 | 0.798204 | 0.000558561 | 0.0668785 | AF 40
1116367 | Nivel 5 | 9.35224 | 0.727325 | 0.000357613 | 0.048761 | AF 40
1116369 | Nivel 5 | 9.35224 | 0.494691 | 0.000357613 | 0.0331649 | AF 40
1116373 | Nivel 5 | 9.35224 | 0.457444 | 0.000357613 | 0.0306677 | AF 40
1116376 | Nivel 5 | 9.34964 | 1.6314 | 0.000558561 | 0.136689 | AF 40
1116379 | Nivel 5 | 9.35224 | 0.313599 | 0.000357613 | 0.0210242 | AF 40
1116383 | Nivel 5 | 9.35224 | 0.315695 | 0.000357613 | 0.0211647 | AF 40
1116386 | Nivel 5 | 9.35224 | 0.119815 | 0.000357613 | 0.00803261 | AF 40
1116389 | Nivel 5 | 9.35224 | 0.876288 | 0.000357613 | 0.0587478 | AF 40
1116391 | Nivel 5 | 9.35224 | 1.0656 | 0.000357613 | 0.0714395 | AF 40
1116393 | Nivel 5 | 9.35224 | 0.483762 | 0.000357613 | 0.0324322 | AF 40
1116397 | Nivel 5 | 9.35224 | 0.753174 | 0.000357613 | 0.050494 | AF 40
1116401 | Nivel 5 | 9.35224 | 0.126956 | 0.000357613 | 0.00851135 | AF 40
1116403 | Nivel 5 | 9.35224 | 0.486997 | 0.000357613 | 0.0326491 | AF 40
1116409 | Nivel 5 | 9.37359 | 1.11337 | 0.000357613 | 0.074642 | AF 40
1116411 | Nivel 5 | 10.4917 | 0.0776598 | 0.000357613 | 0.00520644 | AF 40
1116417 | Nivel 5 | 9.35224 | 0.736455 | 0.000357613 | 0.0493731 | AF 40
1116421 | Nivel 5 | 9.37359 | 0.264213 | 0.000357613 | 0.0177132 | AF 40
1116423 | Nivel 5 | 9.6417 | 0.0690775 | 0.000357613 | 0.00463107 | AF 40
1116429 | Nivel 5 | 9.6622 | 0.216278 | 0.000357613 | 0.0144996 | AF 40
1116435 | Nivel 5 | 9.37359 | 0.516813 | 0.000357613 | 0.0346479 | AF 40
1116437 | Nivel 5 | 9.8943 | 0.0640775 | 0.000357613 | 0.00429586 | AF 40
1116443 | Nivel 5 | 9.9148 | 0.216278 | 0.000357613 | 0.0144996 | AF 40
1116449 | Nivel 5 | 9.37359 | 0.914213 | 0.000357613 | 0.0612903 | AF 40
1116451 | Nivel 5 | 10.2917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 40
1116457 | Nivel 5 | 10.3122 | 0.216278 | 0.000357613 | 0.0144996 | AF 40
1116461 | Nivel 5 | 9.37359 | 0.714213 | 0.000357613 | 0.0478819 | AF 40
1116463 | Nivel 5 | 10.0917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 40
1116469 | Nivel 5 | 10.1122 | 0.216278 | 0.000357613 | 0.0144996 | AF 40
1116479 | Nivel 5 | 9.37359 | 0.614213 | 0.000357613 | 0.0411778 | AF 40
1116481 | Nivel 5 | 9.9917 | 0.0540775 | 0.000357613 | 0.00362544 | AF 40
1116487 | Nivel 5 | 10.0122 | 0.216278 | 0.000357613 | 0.0144996 | AF 40
1116495 | Nivel 5 | 9.37359 | 1.01421 | 0.000357613 | 0.0679944 | AF 40
1116497 | Nivel 5 | 10.3917 | 0.0760338 | 0.000357613 | 0.00509742 | AF 40
1116501 | Nivel 5 | 10.4122 | 0.191278 | 0.000357613 | 0.0128235 | AF 40
1116505 | Nivel 5 | 10.413 | 0.0554563 | 0.000357613 | 0.00371788 | AF 40
1116510 | Nivel 5 | 10.5315 | 0.0685 | 0.000357613 | 0.00459235 | AF 40
1116514 | Nivel 5 | 9.3492 | 1.2056 | 0.000558561 | 0.101013 | AF 57
1116516 | Nivel 5 | 9.3492 | 1.96111 | 0.000558561 | 0.164314 | AF 57
1116520 | Nivel 5 | 9.35181 | 0.75886 | 0.000357613 | 0.0508752 | AF 57
1116525 | Nivel 5 | 9.3492 | 0.937378 | 0.000558561 | 0.0785394 | AF 57
1116528 | Nivel 5 | 9.35181 | 0.624182 | 0.000357613 | 0.0418461 | AF 57
1116530 | Nivel 5 | 9.35181 | 0.499732 | 0.000357613 | 0.0335028 | AF 57
1116534 | Nivel 5 | 9.35181 | 0.52827 | 0.000357613 | 0.035416 | AF 57
1116537 | Nivel 5 | 9.3492 | 1.50954 | 0.000558561 | 0.126479 | AF 57
1116540 | Nivel 5 | 9.35181 | 0.313599 | 0.000357613 | 0.0210242 | AF 57
1116544 | Nivel 5 | 9.35181 | 0.213913 | 0.000357613 | 0.014341 | AF 57
1116546 | Nivel 5 | 9.35181 | 0.77535 | 0.000357613 | 0.0519807 | AF 57
1116548 | Nivel 5 | 9.35181 | 0.701569 | 0.000357613 | 0.0470343 | AF 57
1116550 | Nivel 5 | 9.35181 | 0.483762 | 0.000357613 | 0.0324322 | AF 57
1116554 | Nivel 5 | 9.35181 | 0.754811 | 0.000357613 | 0.0506038 | AF 57
1116558 | Nivel 5 | 9.35181 | 0.124303 | 0.000357613 | 0.0083335 | AF 57
1116560 | Nivel 5 | 9.35181 | 0.486997 | 0.000357613 | 0.0326491 | AF 57
1116566 | Nivel 5 | 9.37315 | 1.11381 | 0.000357613 | 0.0746713 | AF 57
1116568 | Nivel 5 | 10.4917 | 0.0776598 | 0.000357613 | 0.00520644 | AF 57
1116574 | Nivel 5 | 9.35181 | 0.736455 | 0.000357613 | 0.0493731 | AF 57
1116578 | Nivel 5 | 9.37315 | 0.264649 | 0.000357613 | 0.0177425 | AF 57
1116580 | Nivel 5 | 9.6417 | 0.0690775 | 0.000357613 | 0.00463107 | AF 57
1116586 | Nivel 5 | 9.6622 | 0.216278 | 0.000357613 | 0.0144996 | AF 57
1116592 | Nivel 5 | 9.37315 | 0.517249 | 0.000357613 | 0.0346772 | AF 57
1116594 | Nivel 5 | 9.8943 | 0.0640775 | 0.000357613 | 0.00429586 | AF 57
1116600 | Nivel 5 | 9.9148 | 0.216278 | 0.000357613 | 0.0144996 | AF 57
1116606 | Nivel 5 | 9.37315 | 0.914646 | 0.000357613 | 0.0613193 | AF 57
1116608 | Nivel 5 | 10.2917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 57
1116614 | Nivel 5 | 10.3122 | 0.216278 | 0.000357613 | 0.0144996 | AF 57
1116618 | Nivel 5 | 9.37315 | 0.714649 | 0.000357613 | 0.0479112 | AF 57
1116620 | Nivel 5 | 10.0917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 57
1116626 | Nivel 5 | 10.1122 | 0.216278 | 0.000357613 | 0.0144996 | AF 57
1116636 | Nivel 5 | 9.37315 | 0.614649 | 0.000357613 | 0.041207 | AF 57
1116638 | Nivel 5 | 9.9917 | 0.0540775 | 0.000357613 | 0.00362544 | AF 57
1116644 | Nivel 5 | 10.0122 | 0.216278 | 0.000357613 | 0.0144996 | AF 57
1116652 | Nivel 5 | 9.37315 | 1.01465 | 0.000357613 | 0.0680237 | AF 57
1116654 | Nivel 5 | 10.3917 | 0.0760338 | 0.000357613 | 0.00509742 | AF 57
1116658 | Nivel 5 | 10.4122 | 0.191278 | 0.000357613 | 0.0128235 | AF 57
1116662 | Nivel 5 | 10.413 | 0.0554562 | 0.000357613 | 0.00371788 | AF 57
1116667 | Nivel 5 | 10.5315 | 0.0685 | 0.000357613 | 0.00459235 | AF 57
1116669 | Nivel 5 | 9.35181 | 0.236602 | 0.000357613 | 0.0158622 | AF 57
1116672 | Nivel 5 | 9.35181 | 0.0765385 | 0.000357613 | 0.00513126 | AF 57
1116677 | Nivel 5 | 9.349 | 5.2737 | 0.000558561 | 0.441864 | AF 6
1116679 | Nivel 5 | 9.34899 | 1.86525 | 0.000558561 | 0.156282 | AF 6
1116683 | Nivel 5 | 9.34964 | 0.394811 | 0.000558561 | 0.0330798 | AF 40
1116685 | Nivel 5 | 9.34901 | 1.8751 | 0.000558561 | 0.157108 | AF 23
1116691 | Nivel 5 | 9.3492 | 1.3887 | 0.000558561 | 0.116354 | AF 57
1116695 | Nivel 5 | 9.3492 | 3.9937 | 0.000558561 | 0.334617 | AF 57
1116699 | Nivel 5 | 9.3492 | 1.81486 | 0.000558561 | 0.152061 | AF 57
1116703 | Nivel 5 | 9.37575 | 0.378703 | 0.000558561 | 0.0317301 | AF 57
1116707 | Nivel 5 | 9.7592 | 0.0812029 | 0.000558561 | 0.00680369 | AF 57
1116711 | Nivel 5 | 9.37555 | 0.543703 | 0.000558561 | 0.0455548 | AF 6
1116715 | Nivel 5 | 9.92399 | 0.124301 | 0.000558561 | 0.0104147 | AF 6
1116719 | Nivel 5 | 9.37557 | 0.723703 | 0.000558561 | 0.0606363 | AF 23
1116723 | Nivel 5 | 10.104 | 0.169301 | 0.000558561 | 0.0141851 | AF 23
1116727 | Nivel 5 | 9.37619 | 0.873703 | 0.000558561 | 0.0732043 | AF 40
1116731 | Nivel 5 | 10.2546 | 0.209301 | 0.000558561 | 0.0175366 | AF 40
1116735 | Nivel 5 | 9.35181 | 0.348258 | 0.000357613 | 0.0233478 | AF 57
1116743 | Nivel 5 | 9.35162 | 0.380945 | 0.000357613 | 0.0255392 | AF 6
1116751 | Nivel 5 | 9.35162 | 0.408258 | 0.000357613 | 0.0273703 | AF 23
1116757 | Nivel 5 | 9.35224 | 0.245114 | 0.000357613 | 0.0164329 | AF 40
1117072 | Nivel 6 | 11.699 | 1.73606 | 0.000558561 | 0.145458 | AF 7
1117076 | Nivel 6 | 11.7016 | 0.767116 | 0.000357613 | 0.0514287 | AF 7
1117081 | Nivel 6 | 11.699 | 0.929121 | 0.000558561 | 0.0778476 | AF 7
1117084 | Nivel 6 | 11.7016 | 0.591494 | 0.000357613 | 0.0396547 | AF 7
1117086 | Nivel 6 | 11.7016 | 0.380489 | 0.000357613 | 0.0255086 | AF 7
1117090 | Nivel 6 | 11.7016 | 0.362752 | 0.000357613 | 0.0243194 | AF 7
1117093 | Nivel 6 | 11.699 | 1.76723 | 0.000558561 | 0.148069 | AF 7
1117096 | Nivel 6 | 11.7016 | 0.313599 | 0.000357613 | 0.0210242 | AF 7
1117100 | Nivel 6 | 11.7016 | 0.315695 | 0.000357613 | 0.0211647 | AF 7
1117103 | Nivel 6 | 11.7016 | 0.1031 | 0.000357613 | 0.006912 | AF 7
1117106 | Nivel 6 | 11.7016 | 0.876288 | 0.000357613 | 0.0587478 | AF 7
1117108 | Nivel 6 | 11.7016 | 0.934683 | 0.000357613 | 0.0626626 | AF 7
1117110 | Nivel 6 | 11.7016 | 0.483762 | 0.000357613 | 0.0324322 | AF 7
1117114 | Nivel 6 | 11.7016 | 0.753174 | 0.000357613 | 0.050494 | AF 7
1117118 | Nivel 6 | 11.7016 | 0.257873 | 0.000357613 | 0.0172882 | AF 7
1117120 | Nivel 6 | 11.7016 | 0.486997 | 0.000357613 | 0.0326491 | AF 7
1117126 | Nivel 6 | 11.723 | 1.11399 | 0.000357613 | 0.0746839 | AF 7
1117128 | Nivel 6 | 12.8417 | 0.0776598 | 0.000357613 | 0.00520644 | AF 7
1117134 | Nivel 6 | 11.7016 | 0.736455 | 0.000357613 | 0.0493731 | AF 7
1117138 | Nivel 6 | 11.723 | 0.264838 | 0.000357613 | 0.0177551 | AF 7
1117140 | Nivel 6 | 11.9917 | 0.0690775 | 0.000357613 | 0.00463107 | AF 7
1117146 | Nivel 6 | 12.0122 | 0.216278 | 0.000357613 | 0.0144996 | AF 7
1117152 | Nivel 6 | 11.723 | 0.517438 | 0.000357613 | 0.0346898 | AF 7
1117154 | Nivel 6 | 12.2443 | 0.0640775 | 0.000357613 | 0.00429586 | AF 7
1117160 | Nivel 6 | 12.2648 | 0.216278 | 0.000357613 | 0.0144996 | AF 7
1117166 | Nivel 6 | 11.723 | 0.914838 | 0.000357613 | 0.0613322 | AF 7
1117168 | Nivel 6 | 12.6417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 7
1117174 | Nivel 6 | 12.6622 | 0.216278 | 0.000357613 | 0.0144996 | AF 7
1117178 | Nivel 6 | 11.723 | 0.714838 | 0.000357613 | 0.0479238 | AF 7
1117180 | Nivel 6 | 12.4417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 7
1117186 | Nivel 6 | 12.4622 | 0.216278 | 0.000357613 | 0.0144996 | AF 7
1117196 | Nivel 6 | 11.723 | 0.614838 | 0.000357613 | 0.0412197 | AF 7
1117198 | Nivel 6 | 12.3417 | 0.0540775 | 0.000357613 | 0.00362544 | AF 7
1117204 | Nivel 6 | 12.3622 | 0.216278 | 0.000357613 | 0.0144996 | AF 7
1117212 | Nivel 6 | 11.723 | 1.01484 | 0.000357613 | 0.0680363 | AF 7
1117214 | Nivel 6 | 12.7417 | 0.0760338 | 0.000357613 | 0.00509742 | AF 7
1117218 | Nivel 6 | 12.7622 | 0.191278 | 0.000357613 | 0.0128235 | AF 7
1117222 | Nivel 6 | 12.763 | 0.0554563 | 0.000357613 | 0.00371788 | AF 7
1117227 | Nivel 6 | 12.8815 | 0.0685 | 0.000357613 | 0.00459235 | AF 7
1117229 | Nivel 6 | 11.699 | 0.653703 | 0.000558561 | 0.0547713 | AC 16
1117231 | Nivel 6 | 11.699 | 1.96106 | 0.000558561 | 0.16431 | AC 16
1117235 | Nivel 6 | 11.7016 | 0.75842 | 0.000357613 | 0.0508457 | AC 16
1117240 | Nivel 6 | 11.699 | 0.937817 | 0.000558561 | 0.0785762 | AC 16
1117243 | Nivel 6 | 11.7016 | 0.564182 | 0.000357613 | 0.0378236 | AC 16
1117245 | Nivel 6 | 11.7016 | 0.499293 | 0.000357613 | 0.0334734 | AC 16
1117249 | Nivel 6 | 11.7016 | 0.529611 | 0.000357613 | 0.0355059 | AC 16
1117252 | Nivel 6 | 11.699 | 1.56954 | 0.000558561 | 0.131506 | AC 16
1117255 | Nivel 6 | 11.7016 | 0.313599 | 0.000357613 | 0.0210242 | AC 16
1117259 | Nivel 6 | 11.7016 | 0.213913 | 0.000357613 | 0.014341 | AC 16
1117261 | Nivel 6 | 11.7016 | 0.77535 | 0.000357613 | 0.0519807 | AC 16
1117263 | Nivel 6 | 11.7016 | 0.664404 | 0.000357613 | 0.0445427 | AC 16
1117265 | Nivel 6 | 11.7016 | 0.483762 | 0.000357613 | 0.0324322 | AC 16
1117269 | Nivel 6 | 11.7016 | 0.791537 | 0.000357613 | 0.0530659 | AC 16
1117273 | Nivel 6 | 11.7016 | 0.0618916 | 0.000357613 | 0.00414931 | AC 16
1117275 | Nivel 6 | 11.7016 | 0.486997 | 0.000357613 | 0.0326491 | AC 16
1117281 | Nivel 6 | 11.723 | 1.11399 | 0.000357613 | 0.0746839 | AC 16
1117283 | Nivel 6 | 12.8417 | 0.0776598 | 0.000357613 | 0.00520644 | AC 16
1117289 | Nivel 6 | 11.7016 | 0.736455 | 0.000357613 | 0.0493731 | AC 16
1117293 | Nivel 6 | 11.723 | 0.264838 | 0.000357613 | 0.0177551 | AC 16
1117295 | Nivel 6 | 11.9917 | 0.0690775 | 0.000357613 | 0.00463107 | AC 16
1117301 | Nivel 6 | 12.0122 | 0.216278 | 0.000357613 | 0.0144996 | AC 16
1117307 | Nivel 6 | 11.723 | 0.517438 | 0.000357613 | 0.0346898 | AC 16
1117309 | Nivel 6 | 12.2443 | 0.0640775 | 0.000357613 | 0.00429586 | AC 16
1117315 | Nivel 6 | 12.2648 | 0.216278 | 0.000357613 | 0.0144996 | AC 16
1117321 | Nivel 6 | 11.723 | 0.914838 | 0.000357613 | 0.0613322 | AC 16
1117323 | Nivel 6 | 12.6417 | 0.0640775 | 0.000357613 | 0.00429586 | AC 16
1117329 | Nivel 6 | 12.6622 | 0.216278 | 0.000357613 | 0.0144996 | AC 16
1117333 | Nivel 6 | 11.723 | 0.714838 | 0.000357613 | 0.0479238 | AC 16
1117335 | Nivel 6 | 12.4417 | 0.0640775 | 0.000357613 | 0.00429586 | AC 16
1117341 | Nivel 6 | 12.4622 | 0.216278 | 0.000357613 | 0.0144996 | AC 16
1117351 | Nivel 6 | 11.723 | 0.614838 | 0.000357613 | 0.0412197 | AC 16
1117353 | Nivel 6 | 12.3417 | 0.0540775 | 0.000357613 | 0.00362544 | AC 16
1117359 | Nivel 6 | 12.3622 | 0.216278 | 0.000357613 | 0.0144996 | AC 16
1117367 | Nivel 6 | 11.723 | 1.01484 | 0.000357613 | 0.0680363 | AC 16
1117369 | Nivel 6 | 12.7417 | 0.0760338 | 0.000357613 | 0.00509742 | AC 16
1117373 | Nivel 6 | 12.7622 | 0.191278 | 0.000357613 | 0.0128235 | AC 16
1117377 | Nivel 6 | 12.763 | 0.0554562 | 0.000357613 | 0.00371788 | AC 16
1117382 | Nivel 6 | 12.8815 | 0.0685 | 0.000357613 | 0.00459235 | AC 16
1117386 | Nivel 6 | 11.7016 | 0.241519 | 0.000357613 | 0.0161918 | AC 16
1117389 | Nivel 6 | 11.7016 | 0.0765385 | 0.000357613 | 0.00513126 | AC 16
1117394 | Nivel 6 | 11.6996 | 0.613703 | 0.000558561 | 0.0514198 | AF 43
1117396 | Nivel 6 | 11.6996 | 1.73606 | 0.000558561 | 0.145458 | AF 43
1117400 | Nivel 6 | 11.7022 | 0.868034 | 0.000357613 | 0.0581943 | AF 43
1117405 | Nivel 6 | 11.6996 | 0.828204 | 0.000558561 | 0.0693921 | AF 43
1117408 | Nivel 6 | 11.7022 | 0.727325 | 0.000357613 | 0.048761 | AF 43
1117410 | Nivel 6 | 11.7022 | 0.494691 | 0.000357613 | 0.0331649 | AF 43
1117414 | Nivel 6 | 11.7022 | 0.427444 | 0.000357613 | 0.0286565 | AF 43
1117417 | Nivel 6 | 11.6996 | 1.6314 | 0.000558561 | 0.136689 | AF 43
1117420 | Nivel 6 | 11.7022 | 0.313599 | 0.000357613 | 0.0210242 | AF 43
1117424 | Nivel 6 | 11.7022 | 0.315695 | 0.000357613 | 0.0211647 | AF 43
1117427 | Nivel 6 | 11.7022 | 0.0898154 | 0.000357613 | 0.00602136 | AF 43
1117430 | Nivel 6 | 11.7022 | 0.876288 | 0.000357613 | 0.0587478 | AF 43
1117432 | Nivel 6 | 11.7022 | 1.0356 | 0.000357613 | 0.0694283 | AF 43
1117434 | Nivel 6 | 11.7022 | 0.483762 | 0.000357613 | 0.0324322 | AF 43
1117438 | Nivel 6 | 11.7022 | 0.753174 | 0.000357613 | 0.050494 | AF 43
1117442 | Nivel 6 | 11.7022 | 0.156956 | 0.000357613 | 0.0105226 | AF 43
1117444 | Nivel 6 | 11.7022 | 0.486997 | 0.000357613 | 0.0326491 | AF 43
1117450 | Nivel 6 | 11.7236 | 1.11337 | 0.000357613 | 0.074642 | AF 43
1117452 | Nivel 6 | 12.8417 | 0.0776598 | 0.000357613 | 0.00520644 | AF 43
1117458 | Nivel 6 | 11.7022 | 0.736455 | 0.000357613 | 0.0493731 | AF 43
1117462 | Nivel 6 | 11.7236 | 0.264213 | 0.000357613 | 0.0177132 | AF 43
1117464 | Nivel 6 | 11.9917 | 0.0690775 | 0.000357613 | 0.00463107 | AF 43
1117470 | Nivel 6 | 12.0122 | 0.216278 | 0.000357613 | 0.0144996 | AF 43
1117476 | Nivel 6 | 11.7236 | 0.516813 | 0.000357613 | 0.0346479 | AF 43
1117478 | Nivel 6 | 12.2443 | 0.0640775 | 0.000357613 | 0.00429586 | AF 43
1117484 | Nivel 6 | 12.2648 | 0.216278 | 0.000357613 | 0.0144996 | AF 43
1117490 | Nivel 6 | 11.7236 | 0.914213 | 0.000357613 | 0.0612903 | AF 43
1117492 | Nivel 6 | 12.6417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 43
1117498 | Nivel 6 | 12.6622 | 0.216278 | 0.000357613 | 0.0144996 | AF 43
1117502 | Nivel 6 | 11.7236 | 0.714213 | 0.000357613 | 0.0478819 | AF 43
1117504 | Nivel 6 | 12.4417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 43
1117510 | Nivel 6 | 12.4622 | 0.216278 | 0.000357613 | 0.0144996 | AF 43
1117520 | Nivel 6 | 11.7236 | 0.614213 | 0.000357613 | 0.0411778 | AF 43
1117522 | Nivel 6 | 12.3417 | 0.0540775 | 0.000357613 | 0.00362544 | AF 43
1117528 | Nivel 6 | 12.3622 | 0.216278 | 0.000357613 | 0.0144996 | AF 43
1117536 | Nivel 6 | 11.7236 | 1.01421 | 0.000357613 | 0.0679944 | AF 43
1117538 | Nivel 6 | 12.7417 | 0.0760338 | 0.000357613 | 0.00509742 | AF 43
1117542 | Nivel 6 | 12.7622 | 0.191278 | 0.000357613 | 0.0128235 | AF 43
1117546 | Nivel 6 | 12.763 | 0.0554563 | 0.000357613 | 0.00371788 | AF 43
1117551 | Nivel 6 | 12.8815 | 0.0685 | 0.000357613 | 0.00459235 | AF 43
1117555 | Nivel 6 | 11.6992 | 1.2006 | 0.000558561 | 0.100594 | AF 61
1117557 | Nivel 6 | 11.6992 | 1.96111 | 0.000558561 | 0.164314 | AF 61
1117561 | Nivel 6 | 11.7018 | 0.76886 | 0.000357613 | 0.0515456 | AF 61
1117566 | Nivel 6 | 11.6992 | 0.927378 | 0.000558561 | 0.0777015 | AF 61
1117569 | Nivel 6 | 11.7018 | 0.624182 | 0.000357613 | 0.0418461 | AF 61
1117571 | Nivel 6 | 11.7018 | 0.509732 | 0.000357613 | 0.0341733 | AF 61
1117575 | Nivel 6 | 11.7018 | 0.53827 | 0.000357613 | 0.0360865 | AF 61
1117578 | Nivel 6 | 11.6992 | 1.50954 | 0.000558561 | 0.126479 | AF 61
1117581 | Nivel 6 | 11.7018 | 0.313599 | 0.000357613 | 0.0210242 | AF 61
1117585 | Nivel 6 | 11.7018 | 0.213913 | 0.000357613 | 0.014341 | AF 61
1117587 | Nivel 6 | 11.7018 | 0.77535 | 0.000357613 | 0.0519807 | AF 61
1117589 | Nivel 6 | 11.7018 | 0.711569 | 0.000357613 | 0.0477047 | AF 61
1117591 | Nivel 6 | 11.7018 | 0.483762 | 0.000357613 | 0.0324322 | AF 61
1117595 | Nivel 6 | 11.7018 | 0.754811 | 0.000357613 | 0.0506038 | AF 61
1117599 | Nivel 6 | 11.7018 | 0.114303 | 0.000357613 | 0.00766308 | AF 61
1117601 | Nivel 6 | 11.7018 | 0.486997 | 0.000357613 | 0.0326491 | AF 61
1117607 | Nivel 6 | 11.7232 | 1.11381 | 0.000357613 | 0.0746713 | AF 61
1117609 | Nivel 6 | 12.8417 | 0.0776598 | 0.000357613 | 0.00520644 | AF 61
1117615 | Nivel 6 | 11.7018 | 0.736455 | 0.000357613 | 0.0493731 | AF 61
1117619 | Nivel 6 | 11.7232 | 0.264649 | 0.000357613 | 0.0177425 | AF 61
1117621 | Nivel 6 | 11.9917 | 0.0690775 | 0.000357613 | 0.00463107 | AF 61
1117627 | Nivel 6 | 12.0122 | 0.216278 | 0.000357613 | 0.0144996 | AF 61
1117633 | Nivel 6 | 11.7232 | 0.517249 | 0.000357613 | 0.0346772 | AF 61
1117635 | Nivel 6 | 12.2443 | 0.0640775 | 0.000357613 | 0.00429586 | AF 61
1117641 | Nivel 6 | 12.2648 | 0.216278 | 0.000357613 | 0.0144996 | AF 61
1117647 | Nivel 6 | 11.7232 | 0.914646 | 0.000357613 | 0.0613193 | AF 61
1117649 | Nivel 6 | 12.6417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 61
1117655 | Nivel 6 | 12.6622 | 0.216278 | 0.000357613 | 0.0144996 | AF 61
1117659 | Nivel 6 | 11.7232 | 0.714649 | 0.000357613 | 0.0479112 | AF 61
1117661 | Nivel 6 | 12.4417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 61
1117667 | Nivel 6 | 12.4622 | 0.216278 | 0.000357613 | 0.0144996 | AF 61
1117677 | Nivel 6 | 11.7232 | 0.614649 | 0.000357613 | 0.041207 | AF 61
1117679 | Nivel 6 | 12.3417 | 0.0540775 | 0.000357613 | 0.00362544 | AF 61
1117685 | Nivel 6 | 12.3622 | 0.216278 | 0.000357613 | 0.0144996 | AF 61
1117693 | Nivel 6 | 11.7232 | 1.01465 | 0.000357613 | 0.0680237 | AF 61
1117695 | Nivel 6 | 12.7417 | 0.0760338 | 0.000357613 | 0.00509742 | AF 61
1117699 | Nivel 6 | 12.7622 | 0.191278 | 0.000357613 | 0.0128235 | AF 61
1117703 | Nivel 6 | 12.763 | 0.0554562 | 0.000357613 | 0.00371788 | AF 61
1117708 | Nivel 6 | 12.8815 | 0.0685 | 0.000357613 | 0.00459235 | AF 61
1117710 | Nivel 6 | 11.7018 | 0.226602 | 0.000357613 | 0.0151918 | AF 61
1117713 | Nivel 6 | 11.7018 | 0.0765385 | 0.000357613 | 0.00513126 | AF 61
1117718 | Nivel 6 | 11.699 | 5.2737 | 0.000558561 | 0.441864 | AF 7
1117720 | Nivel 6 | 11.699 | 1.8751 | 0.000558561 | 0.157108 | AF 7
1117724 | Nivel 6 | 11.6996 | 0.394811 | 0.000558561 | 0.0330798 | AF 43
1117726 | Nivel 6 | 11.699 | 1.8751 | 0.000558561 | 0.157108 | AC 16
1117732 | Nivel 6 | 11.6992 | 1.3887 | 0.000558561 | 0.116354 | AF 61
1117736 | Nivel 6 | 11.6992 | 3.9987 | 0.000558561 | 0.335036 | AF 61
1117740 | Nivel 6 | 11.6992 | 1.81486 | 0.000558561 | 0.152061 | AF 61
1117744 | Nivel 6 | 11.7257 | 0.378703 | 0.000558561 | 0.0317301 | AF 61
1117748 | Nivel 6 | 12.1092 | 0.0812029 | 0.000558561 | 0.00680369 | AF 61
1117752 | Nivel 6 | 11.7255 | 0.543703 | 0.000558561 | 0.0455548 | AF 7
1117756 | Nivel 6 | 12.274 | 0.124301 | 0.000558561 | 0.0104147 | AF 7
1117760 | Nivel 6 | 11.7256 | 0.723703 | 0.000558561 | 0.0606363 | AC 16
1117764 | Nivel 6 | 12.454 | 0.169301 | 0.000558561 | 0.0141851 | AC 16
1117768 | Nivel 6 | 11.7262 | 0.873703 | 0.000558561 | 0.0732043 | AF 43
1117772 | Nivel 6 | 12.6046 | 0.209301 | 0.000558561 | 0.0175366 | AF 43
1117776 | Nivel 6 | 11.7018 | 0.348258 | 0.000357613 | 0.0233478 | AF 61
1117784 | Nivel 6 | 11.7016 | 0.380945 | 0.000357613 | 0.0255392 | AF 7
1117792 | Nivel 6 | 11.7016 | 0.408258 | 0.000357613 | 0.0273703 | AC 16
1117798 | Nivel 6 | 11.7022 | 0.245114 | 0.000357613 | 0.0164329 | AF 43
1198576 | Nivel 1 | -0.630366 | 0.693766 | 0.00418476 | 0.159106 | AF 2
1203643 | Nivel 1 | 12.139 | 2.40952 | 0.000357613 | 0.161538 | AF 2

# IfcPipeSegment: Pipe Types:D2020-PVC.LL (50)
In: Nivel 1
Type - PredefinedType: RIGIDSEGMENT
Classification: 21.04.20.30.20 Uniformat (Uniformat); Group: ALL 1
Pset_EnvironmentalImpactIndicators - Reference: D2020-PVC.LL; sets with these values: 2
Name (Pipe Types:D2020-PVC.LL:...) | InvertElevation (m) | Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2)
1083973 | 0.271642 | 13.2043 | 0.00535259 | 3.42481
1084316 | 0.0949757 | 0.150423 | 0.00535259 | 0.0390151
1084329 | -0.529316 | 0.607864 | 0.00535259 | 0.157662
1084454 | 13.6378 | 0.287839 | 0.00535259 | 0.0746569
1084501 | 13.8483 | 0.71381 | 0.00535259 | 0.185141
1084513 | 13.9666 | 0.341045 | 0.00535259 | 0.0884569
1084880 | 13.7122 | 0.0114598 | 0.00535259 | 0.00297231
1085112 | 14.0519 | 0.048113 | 0.00535259 | 0.0124791
1085181 | 14.0972 | 0.970113 | 0.00535259 | 0.251618
1085189 | 14.2164 | 0.0889121 | 0.00535259 | 0.0230611
1086139 | 0.271642 | 13.2043 | 0.00535259 | 3.42481
1086141 | 0.0924754 | 0.153959 | 0.00535259 | 0.0399322
1086145 | -0.543275 | 0.625361 | 0.00535259 | 0.1622
1086149 | 13.6378 | 0.287839 | 0.00535259 | 0.0746569
1086153 | 13.8482 | 0.7138 | 0.00535259 | 0.185138
1086157 | 13.9625 | 0.345122 | 0.00535259 | 0.0895143
1086161 | 13.7122 | 0.0104642 | 0.00535259 | 0.00271411
1086177 | 14.0972 | 0.970113 | 0.00535259 | 0.251618
1086179 | 14.2164 | 0.0889121 | 0.00535259 | 0.0230611
1086187 | -0.672767 | 2.96364 | 0.00535259 | 0.768679
1086191 | -0.673309 | 0.0843117 | 0.00535259 | 0.0218679
1086199 | -0.797123 | 0.158495 | 0.0102593 | 0.0569129
1086203 | -0.84143 | 3.50547 | 0.0102593 | 1.25876
1086313 | -0.676509 | 0.919513 | 0.00535259 | 0.238494
1086417 | -0.675853 | 0.275782 | 0.00535259 | 0.0715295
1086586 | -0.674962 | 2.25493 | 0.00535259 | 0.584862
1089494 | -0.662506 | 3.70368 | 0.00535259 | 0.960623
1089514 | -0.662506 | 0.23041 | 0.00535259 | 0.0597615
1089522 | -0.6611 | 0.852748 | 0.00535259 | 0.221177
1089675 | 13.8662 | 0.10861 | 0.00535259 | 0.0281701
1089687 | 13.9815 | 0.11927 | 0.00535259 | 0.0309351
1089920 | -0.542348 | 0.544312 | 0.00535259 | 0.141178
1090149 | 0.0125309 | 0.092736 | 0.00535259 | 0.0240529
1090164 | 0.148406 | 13.6793 | 0.00535259 | 3.54801
1199767 | 13.8855 | 0.062609 | 0.00535259 | 0.0162389
1199776 | 13.9598 | 0.0989201 | 0.00535259 | 0.0256569
1199813 | 13.9367 | 0.100695 | 0.00535259 | 0.0261172
1200219 | 13.8845 | 0.0470599 | 0.00535259 | 0.0122059
1200228 | 13.9588 | 0.0999156 | 0.00535259 | 0.0259151
1200264 | 13.9246 | 0.0934762 | 0.00535259 | 0.0242449
1200676 | 14.0393 | 0.0607151 | 0.00535259 | 0.0157477
1246013 | -0.691597 | 0.0507971 | 0.0102593 | 0.0182404
1246307 | -0.705109 | 2.43754 | 0.0102593 | 0.875282
1331109 | -0.578311 | 2.94331 | 0.00285724 | 0.55776
1331701 | -0.662136 | 5.23247 | 0.00285724 | 0.991558
1331715 | -0.657918 | 0.280889 | 0.00285724 | 0.0532286
1331725 | -0.656324 | 0.782271 | 0.00285724 | 0.148241
1331955 | -0.652223 | 0.108099 | 0.00285724 | 0.0204848
1331969 | -0.651601 | 0.345285 | 0.00285724 | 0.0654319
1379861 | -0.673333 | 0.059691 | 0.00535259 | 0.015482

# IfcPipeSegment: Pipe Types:D2020-PVC.S (1027)
Type - PredefinedType: RIGIDSEGMENT
Classification: 21.04.20.20.30 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: D2020-PVC.S; sets with these values: 2
Name (Pipe Types:D2020-PVC.S:...) | In | InvertElevation (m) | Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Group
948051 | Nivel 1 | 2.36977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
948059 | Nivel 1 | 2.36914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
948076 | Nivel 1 | 2.36484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
948203 | Nivel 2 | 2.36416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
948221 | Nivel 2 | 2.36216 | 0.360417 | 0.00285724 | 0.0682993 | AR-DOM 1
948442 | Nivel 2 | 2.18095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
948448 | Nivel 2 | 2.18019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
948489 | Nivel 2 | 2.17304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
948512 | Nivel 2 | 2.1701 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
948526 | Nivel 2 | 2.17195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
948535 | Nivel 2 | 2.17231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
948736 | Nivel 2 | 2.17366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
948772 | Nivel 2 | 2.17909 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
948785 | Nivel 2 | 2.17924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
948788 | Nivel 2 | 2.17971 | 0.048465 | 0.00285724 | 0.00918416 | AR-DOM 1
948823 | Nivel 2 | 2.17941 | 0.200586 | 0.0102593 | 0.0720272 | AR-DOM 1
949081 | Nivel 2 | 2.02722 | 0.186873 | 0.0102593 | 0.0671031 | AR-DOM 1
949468 | Nivel 2 | 2.94498 | 0.916438 | 0.0102593 | 0.329078 | AR-DOM 1
950577 | Nivel 2 | 2.3553 | 1.2806 | 0.00285724 | 0.242675 | AR-DOM 1
950770 | Nivel 2 | 1.72681 | 0.609451 | 0.00285724 | 0.115492 | AR-DOM 1
951923 | Nivel 2 | 1.91437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
951983 | Nivel 2 | 1.74076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
953014 | Nivel 2 | 2.8332 | 0.348069 | 0.00285724 | 0.0659593 | AR-DOM 1
953330 | Nivel 2 | 2.57664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
953341 | Nivel 2 | 2.83626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
953534 | Nivel 2 | 2.22177 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
953738 | Nivel 2 | 2.49949 | 0.0112704 | 0.00285724 | 0.00213576 | AR-DOM 1; VENT 1
954031 | Nivel 2 | 2.17195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
954277 | Nivel 2 | 2.17362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
954346 | Nivel 2 | 2.25598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
954354 | Nivel 2 | 2.82276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
955400 | Nivel 2 | 1.8399 | 0.0273918 | 0.00285724 | 0.00519078 | AR-DOM 1
955409 | Nivel 2 | 1.95168 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
955600 | Nivel 2 | 1.84021 | 0.1618 | 0.00285714 | 0.0306612 | AR-DOM 1
956228 | Nivel 2 | 2.18109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
956422 | Nivel 1 | 2.44432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
956432 | Nivel 1 | 2.92234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
957132 | Nivel 2 | 2.2621 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
957164 | Nivel 2 | 2.33653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
957400 | Nivel 2 | 3.12611 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
957438 | Nivel 2 | 3.06644 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1064554 | Nivel 2 | -0.638327 | 2.14975 | 0.0102593 | 0.77194 | AR-DOM 1
1064728 | Nivel 2 | -0.633258 | 2.14468 | 0.0102593 | 0.77012 | AR-DOM 1
1067274 | Nivel 1 | -0.662946 | 0.123295 | 0.0102593 | 0.0442734 | AR-DOM 4
1067369 | Nivel 1 | -0.511347 | 0.541347 | 0.0102593 | 0.194389 | AR-DOM 4
1068181 | Nivel 1 | -0.67564 | 0.0913168 | 0.0102593 | 0.0327904 | AR-DOM 4
1068203 | Nivel 1 | -0.525589 | 0.555589 | 0.0102593 | 0.199503 | AR-DOM 4
1068401 | Nivel 1 | -0.653984 | 0.183539 | 0.00285724 | 0.0347809 | AR-DOM 4
1068424 | Nivel 1 | -0.652872 | 0.138261 | 0.00285724 | 0.0262005 | AR-DOM 4
1068639 | Nivel 1 | -0.633437 | 0.301191 | 0.00285724 | 0.057076 | AR-DOM 4
1068655 | Nivel 1 | -0.631743 | 0.22673 | 0.00285724 | 0.0429656 | AR-DOM 4
1068669 | Nivel 1 | -0.630419 | 0.186127 | 0.00285724 | 0.0352713 | AR-DOM 4
1068873 | Nivel 1 | -0.639873 | 0.106365 | 0.00285724 | 0.0201562 | AR-DOM 4
1069332 | Nivel 1 | -0.686572 | 0.974731 | 0.0102593 | 0.35001 | AR-DOM 4
1069535 | Nivel 1 | -0.666426 | 0.397818 | 0.0102593 | 0.14285 | AR-DOM 4
1069599 | Nivel 1 | -0.638075 | 0.668075 | 0.00285724 | 0.126601 | AR-DOM 4
1069696 | Nivel 1 | -0.68817 | 0.243379 | 0.0102593 | 0.0873936 | AR-DOM 4
1069753 | Nivel 1 | -0.555969 | 0.470936 | 0.00285724 | 0.0892429 | AR-DOM 4
1069768 | Nivel 1 | -0.0671417 | 0.137912 | 0.00285724 | 0.0261344 | AR-DOM 4
1070141 | Nivel 1 | 0.00591771 | 0.548032 | 0.00285724 | 0.103853 | AR-DOM 4
1070149 | Nivel 1 | 0.57231 | 0.0439524 | 0.00285724 | 0.00832901 | AR-DOM 4
1070292 | Nivel 1 | -0.578684 | 0.498511 | 0.00285724 | 0.0944682 | AR-DOM 4
1070305 | Nivel 1 | -0.061133 | 0.116819 | 0.00285724 | 0.0221372 | AR-DOM 4
1070321 | Nivel 1 | 0.013246 | 0.540704 | 0.00285724 | 0.102464 | AR-DOM 4
1070633 | Nivel 1 | 0.572991 | 0.0539517 | 0.00285724 | 0.0102239 | AR-DOM 4
1070736 | Nivel 1 | -0.713844 | 5.07841 | 0.0102593 | 1.82358 | AR-DOM 4
1070888 | Nivel 1 | -0.560667 | 0.469617 | 0.00285724 | 0.0889928 | AR-DOM 4
1070921 | Nivel 1 | -0.0720094 | 0.131203 | 0.00285724 | 0.0248631 | AR-DOM 4
1070933 | Nivel 1 | 0.0021665 | 0.551783 | 0.00285724 | 0.104563 | AR-DOM 4
1071227 | Nivel 1 | 0.572991 | 0.033952 | 0.00285724 | 0.00643393 | AR-DOM 4
1071557 | Nivel 1 | -0.633437 | 0.186078 | 0.00285724 | 0.0352619 | AR-DOM 4
1071574 | Nivel 1 | -0.635055 | 0.14905 | 0.00285724 | 0.0282451 | AR-DOM 4
1071579 | Nivel 1 | -0.622556 | 0.959555 | 0.00285724 | 0.181836 | AR-DOM 4
1071590 | Nivel 1 | -0.616891 | 0.0495751 | 0.00285724 | 0.00939453 | AR-DOM 4
1071600 | Nivel 1 | -0.616453 | 0.213835 | 0.00285724 | 0.0405219 | AR-DOM 4
1071857 | Nivel 1 | -0.542038 | 0.445178 | 0.00285724 | 0.0843617 | AR-DOM 4
1071870 | Nivel 1 | -0.0778187 | 0.117908 | 0.00285724 | 0.0223437 | AR-DOM 4
1071880 | Nivel 1 | -0.00370926 | 0.557659 | 0.00285724 | 0.105677 | AR-DOM 4
1072138 | Nivel 1 | 0.572991 | 0.0464518 | 0.00285724 | 0.00880266 | AR-DOM 4
1072374 | Nivel 1 | -0.680538 | 0.145485 | 0.0102593 | 0.0522413 | AR-DOM 4
1072423 | Nivel 1 | -0.652097 | 0.162272 | 0.00285724 | 0.0307506 | AR-DOM 4
1072432 | Nivel 1 | -0.678651 | 0.389819 | 0.0102593 | 0.139978 | AR-DOM 4
1072435 | Nivel 1 | -0.641225 | 0.921088 | 0.00285724 | 0.174547 | AR-DOM 4
1072446 | Nivel 1 | -0.635737 | 0.063783 | 0.00285724 | 0.0120869 | AR-DOM 4
1072456 | Nivel 1 | -0.635225 | 0.207671 | 0.00285724 | 0.0393539 | AR-DOM 4
1072634 | Nivel 1 | -0.641226 | 0.123692 | 0.00285724 | 0.0234397 | AR-DOM 4
1072643 | Nivel 1 | -0.645888 | 0.757162 | 0.00285724 | 0.143483 | AR-DOM 4
1072650 | Nivel 1 | -0.64044 | 0.861034 | 0.00285724 | 0.163167 | AR-DOM 4
1072796 | Nivel 1 | -0.635742 | 0.561007 | 0.00285724 | 0.106311 | AR-DOM 4
1072802 | Nivel 1 | -0.632745 | 0.161688 | 0.00285724 | 0.0306399 | AR-DOM 4
1072813 | Nivel 1 | -0.631746 | 0.205299 | 0.00285724 | 0.0389043 | AR-DOM 4
1072930 | Nivel 1 | -0.616892 | 0.491234 | 0.00285724 | 0.0930892 | AR-DOM 4
1072944 | Nivel 1 | -0.614249 | 0.243555 | 0.00285724 | 0.0461538 | AR-DOM 4
1072954 | Nivel 1 | -0.612842 | 0.162305 | 0.00285724 | 0.030757 | AR-DOM 4
1073104 | Nivel 1 | -0.622556 | 0.16166 | 0.00285724 | 0.0306348 | AR-DOM 4
1073113 | Nivel 1 | -0.627626 | 0.84443 | 0.00285724 | 0.16002 | AR-DOM 4
1073851 | Nivel 1 | -0.63487 | 0.66487 | 0.00285724 | 0.125993 | AR-DOM 4
1073955 | Nivel 1 | -0.621557 | 0.875974 | 0.00285724 | 0.165998 | AR-DOM 4
1073990 | Nivel 1 | -0.616024 | 0.646024 | 0.00285724 | 0.122422 | AR-DOM 4
1074277 | Nivel 1 | -0.538605 | 0.434427 | 0.00285724 | 0.0823244 | AR-DOM 4
1074340 | Nivel 1 | -0.0851368 | 0.101902 | 0.00285724 | 0.0193105 | AR-DOM 4
1074407 | Nivel 1 | -0.5572 | 0.4608 | 0.00285724 | 0.087322 | AR-DOM 4
1074434 | Nivel 1 | -0.0773594 | 0.133962 | 0.00285724 | 0.0253859 | AR-DOM 4
1074446 | Nivel 1 | -0.0031697 | 0.55782 | 0.00285724 | 0.105707 | AR-DOM 4
1074856 | Nivel 1 | 0.573691 | 0.0339044 | 0.00285724 | 0.00642491 | AR-DOM 4
1074928 | Nivel 1 | -0.011122 | 0.577084 | 0.00285724 | 0.109358 | AR-DOM 4
1074936 | Nivel 1 | 0.585017 | 0.0389524 | 0.00285724 | 0.00738152 | AR-DOM 4
1075093 | Nivel 1 | -0.660632 | 0.0665716 | 0.0102593 | 0.0239048 | AR-DOM 4
1075095 | Nivel 1 | -0.509317 | 0.539317 | 0.0102593 | 0.19366 | AR-DOM 4
1075101 | Nivel 1 | -0.67315 | 0.0665631 | 0.0102593 | 0.0239017 | AR-DOM 4
1075105 | Nivel 1 | -0.523099 | 0.553099 | 0.0102593 | 0.198609 | AR-DOM 4
1075111 | Nivel 1 | -0.651585 | 0.183521 | 0.00285724 | 0.0347774 | AR-DOM 4
1075115 | Nivel 1 | -0.650472 | 0.0981229 | 0.00285724 | 0.0185944 | AR-DOM 4
1075121 | Nivel 1 | -0.631048 | 0.341132 | 0.00285724 | 0.0646449 | AR-DOM 4
1075125 | Nivel 1 | -0.629154 | 0.170077 | 0.00285724 | 0.0322297 | AR-DOM 4
1075129 | Nivel 1 | -0.628114 | 0.186038 | 0.00285724 | 0.0352543 | AR-DOM 4
