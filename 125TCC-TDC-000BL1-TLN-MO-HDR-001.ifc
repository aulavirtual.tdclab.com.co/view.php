Properties of the parts of a building model (IFC4), part 15 of 21

# IfcDistributionPort (13044)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_1248820_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248822_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248828_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248822_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248830_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248824_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248826_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248826_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248828_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248835_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248839_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248835_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248851_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248837_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248839_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248837_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248841_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248843_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248849_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248843_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248851_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248845_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248847_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248847_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1248849_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1307662_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 1
Port_1307666_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 1
Port_1307662_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 1
Port_1307664_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 1
Port_1307666_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 1
Port_1307664_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 1
Port_1310311_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 2
Port_1310315_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 2
Port_1310311_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 2
Port_1310313_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 2
Port_1310315_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 2
Port_1310313_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 2
Port_1310325_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 3
Port_1310329_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 3
Port_1310325_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 3
Port_1310327_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 3
Port_1310329_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 3
Port_1310327_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 3
Port_1310359_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 4
Port_1310363_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 4
Port_1310359_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 4
Port_1310361_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 4
Port_1310363_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 4
Port_1310361_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 4
Port_1310388_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 5
Port_1310392_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 5
Port_1310388_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 5
Port_1310390_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 5
Port_1310392_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 5
Port_1310390_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 5
Port_1310395_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 7
Port_1310399_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 7
Port_1310395_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 7
Port_1310397_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 7
Port_1310399_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 7
Port_1310397_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 7
Port_1310402_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 9
Port_1310406_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 9
Port_1310402_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 9
Port_1310404_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 9
Port_1310406_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 9
Port_1310404_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 9
Port_1310409_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 11
Port_1310413_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 11
Port_1310409_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 11
Port_1310411_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 11
Port_1310413_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 11
Port_1310411_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 11
Port_1310426_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 13
Port_1310430_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 13
Port_1310426_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 13
Port_1310428_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 13
Port_1310430_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 13
Port_1310428_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 13
Port_1310433_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 15
Port_1310437_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 15
Port_1310433_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 15
Port_1310435_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 15
Port_1310437_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 15
Port_1310435_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 15
Port_1310440_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 17
Port_1310444_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 17
Port_1310440_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 17
Port_1310442_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 17
Port_1310444_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 17
Port_1310442_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 17
Port_1310447_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 19
Port_1310451_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 19
Port_1310447_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 19
Port_1310449_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 19
Port_1310451_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 19
Port_1310449_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 19
Port_1310464_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 21
Port_1310468_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 21
Port_1310464_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 21
Port_1310466_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 21
Port_1310468_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 21
Port_1310466_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 21
Port_1310471_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 23
Port_1310475_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 23
Port_1310471_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 23
Port_1310473_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 23
Port_1310475_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 23
Port_1310473_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 23
Port_1310478_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 25
Port_1310482_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 25
Port_1310478_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 25
Port_1310480_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 25
Port_1310482_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 25
Port_1310480_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 25
Port_1310485_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 27
Port_1310489_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 27
Port_1310485_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 27
Port_1310487_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 27
Port_1310489_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 27
Port_1310487_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 27
Port_1310502_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 29
Port_1310506_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 29
Port_1310502_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 29
Port_1310504_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 29
Port_1310506_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 29
Port_1310504_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 29
Port_1310509_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 31
Port_1310513_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 31
Port_1310509_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 31
Port_1310511_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 31
Port_1310513_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 31
Port_1310511_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 31
Port_1310516_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 33
Port_1310520_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 33
Port_1310516_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 33
Port_1310518_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 33
Port_1310520_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 33
Port_1310518_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 33
Port_1310523_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 35
Port_1310527_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 35
Port_1310523_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 35
Port_1310525_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 35
Port_1310527_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 35
Port_1310525_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 35
Port_1310540_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 37
Port_1310544_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 37
Port_1310540_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 37
Port_1310542_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 37
Port_1310544_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 37
Port_1310542_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 37
Port_1310547_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 39
Port_1310551_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 39
Port_1310547_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 39
Port_1310549_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 39
Port_1310551_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 39
Port_1310549_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 39
Port_1310554_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 41
Port_1310558_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 41
Port_1310554_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 41
Port_1310556_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 41
Port_1310558_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 41
Port_1310556_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 41
Port_1310561_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 43
Port_1310565_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 43
Port_1310561_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 43
Port_1310563_0 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 43
Port_1310565_2 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 43
Port_1310563_1 | SOURCEANDSINK | DUCT | VENTILATION | Mechanical No Aplica - Supply Air 43
Port_1311128_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 27
Port_1311139_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 27
Port_1311128_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 27
Port_1311139_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 27
Port_1330722_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1330725_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1330722_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1330729_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1330727_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1330729_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1330727_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1330734_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1331109_0 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1486827_1 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1331109_1 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1331835_1 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1331648_1 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1331648_2 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1379861_0 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1331648_3 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1331701_0 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1379874_1 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1331701_1 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1379878_1 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1331715_0 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1379874_2 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1331715_1 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1379323_1 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1331725_0 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1379323_2 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1331725_1 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1378550_2 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1331955_0 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1378550_1 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1331955_1 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1486792_2 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1331969_0 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1486792_1 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1331969_1 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1486827_2 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1344840_1 | SOURCEANDSINK | PIPE | VENT | VENT 1
Port_1345971_2 | SOURCEANDSINK | PIPE | VENT | VENT 1
Port_1344856_1 | SOURCEANDSINK | PIPE | VENT | VENT 2
Port_1346091_2 | SOURCEANDSINK | PIPE | VENT | VENT 2
Port_1345173_0 | SOURCEANDSINK | PIPE | VENT | VENT 3
Port_1346418_1 | SOURCEANDSINK | PIPE | VENT | VENT 3
Port_1345173_1 | SOURCEANDSINK | PIPE | VENT | VENT 3
Port_1486476_2 | SOURCEANDSINK | PIPE | VENT | VENT 3
Port_1345196_1 | SOURCEANDSINK | PIPE | VENT | VENT 3
Port_1346242_2 | SOURCEANDSINK | PIPE | VENT | VENT 3
Port_1345343_1 | SOURCEANDSINK | PIPE | VENT | VENT 1
Port_1346011_2 | SOURCEANDSINK | PIPE | VENT | VENT 1
Port_1345549_1 | SOURCEANDSINK | PIPE | VENT | VENT 6
Port_1346491_2 | SOURCEANDSINK | PIPE | VENT | VENT 6
Port_1345606_0 | SOURCEANDSINK | PIPE | VENT | VENT 6
Port_1346491_1 | SOURCEANDSINK | PIPE | VENT | VENT 6
Port_1345606_1 | SOURCEANDSINK | PIPE | VENT | VENT 6
Port_1346527_1 | SOURCEANDSINK | PIPE | VENT | VENT 6
Port_1345732_1 | SOURCEANDSINK | PIPE | VENT | VENT 2
Port_1346126_2 | SOURCEANDSINK | PIPE | VENT | VENT 2
Port_1345971_1 | SOURCEANDSINK | PIPE | VENT | VENT 1
Port_1345981_0 | SOURCEANDSINK | PIPE | VENT | VENT 1
Port_1345981_1 | SOURCEANDSINK | PIPE | VENT | VENT 1
Port_1346011_1 | SOURCEANDSINK | PIPE | VENT | VENT 1
Port_1346091_1 | SOURCEANDSINK | PIPE | VENT | VENT 2
Port_1346101_0 | SOURCEANDSINK | PIPE | VENT | VENT 2
Port_1346101_1 | SOURCEANDSINK | PIPE | VENT | VENT 2
Port_1346126_1 | SOURCEANDSINK | PIPE | VENT | VENT 2
Port_1346234_0 | SOURCEANDSINK | PIPE | VENT | VENT 3
Port_1346242_1 | SOURCEANDSINK | PIPE | VENT | VENT 3
Port_1346234_1 | SOURCEANDSINK | PIPE | VENT | VENT 3
Port_1346418_2 | SOURCEANDSINK | PIPE | VENT | VENT 3
Port_1379861_1 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1379878_2 | SOURCEANDSINK | PIPE | SEWAGE | ALL 1
Port_1486476_1 | SOURCEANDSINK | PIPE | VENT | VENT 3
Port_1486507_1 | SOURCEANDSINK | PIPE | VENT | VENT 3
Port_1486510_1 | SOURCEANDSINK | PIPE | VENT | VENT 3

# IfcDistributionSystem: Desagües Aguas Lluvias, ALL 1
PredefinedType: SEWAGE
Pset_DistributionSystemCommon - Reference: Desagües Aguas Lluvias

# IfcDistributionSystem: Desagües Aguas Residuales (2)
PredefinedType: DOMESTICCOLDWATER
Pset_DistributionSystemCommon - Reference: Desagües Aguas Residuales
Name
AR-DOM 1
AR-DOM 4

# IfcDistributionSystem: Desagües Ventilación (4)
PredefinedType: VENT
Pset_DistributionSystemCommon - Reference: Desagües Ventilación
Name
VENT 1
VENT 2
VENT 3
VENT 6

# IfcDistributionSystem: No Aplica - Supply Air (24)
PredefinedType: VENTILATION
Pset_DistributionSystemCommon - Reference: No Aplica - Supply Air
Name
Mechanical No Aplica - Supply Air 1
Mechanical No Aplica - Supply Air 2
Mechanical No Aplica - Supply Air 3
Mechanical No Aplica - Supply Air 4
Mechanical No Aplica - Supply Air 5
Mechanical No Aplica - Supply Air 7
Mechanical No Aplica - Supply Air 9
Mechanical No Aplica - Supply Air 11
Mechanical No Aplica - Supply Air 13
Mechanical No Aplica - Supply Air 15
Mechanical No Aplica - Supply Air 17
Mechanical No Aplica - Supply Air 19
Mechanical No Aplica - Supply Air 21
Mechanical No Aplica - Supply Air 23
Mechanical No Aplica - Supply Air 25
Mechanical No Aplica - Supply Air 27
Mechanical No Aplica - Supply Air 29
Mechanical No Aplica - Supply Air 31
Mechanical No Aplica - Supply Air 33
Mechanical No Aplica - Supply Air 35
Mechanical No Aplica - Supply Air 37
Mechanical No Aplica - Supply Air 39
Mechanical No Aplica - Supply Air 41
Mechanical No Aplica - Supply Air 43

# IfcDistributionSystem: Red Contra Incendio, RCI 1
PredefinedType: FIREPROTECTION
Pset_DistributionSystemCommon - Reference: Red Contra Incendio

# IfcDistributionSystem: Red de Gas (26)
PredefinedType: USERDEFINED
Pset_DistributionSystemCommon - Reference: Red de Gas
Name
GAS 2
GAS 5
GAS 6
GAS 8
GAS 9
GAS 1
GAS 4
GAS 10
GAS 12
GAS 3
GAS 11
GAS 14
GAS 16
GAS 7
GAS 15
GAS 18
GAS 20
GAS 13
GAS 19
GAS 22
GAS 24
GAS 17
GAS 23
GAS 26
GAS 28
GAS 27

# IfcDistributionSystem: Suministro de Agua Caliente (25)
PredefinedType: DOMESTICHOTWATER
Pset_DistributionSystemCommon - Reference: Suministro de Agua Caliente
Name
AC 1
AC 2
AC 4
AC 5
AC 3
AC 8
AC 11
AC 14
AC 6
AC 10
AC 15
AC 18
AC 7
AC 13
AC 19
AC 22
AC 9
AC 17
AC 23
AC 26
AC 12
AC 21
AC 27
AC 30
AC 16

# IfcDistributionSystem: Suministro de Agua Fría (24)
PredefinedType: DOMESTICCOLDWATER
Pset_DistributionSystemCommon - Reference: Suministro de Agua Fría
Name
AF 2
AF 1
AF 16
AF 30
AF 44
AF 3
AF 17
AF 31
AF 45
AF 4
AF 19
AF 34
AF 49
AF 5
AF 21
AF 37
AF 53
AF 6
AF 23
AF 40
AF 57
AF 7
AF 43
AF 61

# IfcDuctFitting: M_Round Elbow:1 D (24)
Type - Material: <Unnamed>
Classification: D3050.50 Uniformat (Uniformat)
Pset_DuctFittingTypeCommon - Reference: 1 D; sets with these values: 2
Name (M_Round Elbow:1 D:...) | In | Group
1307666 | Nivel 2 | Mechanical No Aplica - Supply Air 1
1310315 | Nivel 2 | Mechanical No Aplica - Supply Air 2
1310329 | Nivel 2 | Mechanical No Aplica - Supply Air 3
1310363 | Nivel 2 | Mechanical No Aplica - Supply Air 4
1310392 | Nivel 1 | Mechanical No Aplica - Supply Air 5
1310399 | Nivel 1 | Mechanical No Aplica - Supply Air 7
1310406 | Nivel 1 | Mechanical No Aplica - Supply Air 9
1310413 | Nivel 1 | Mechanical No Aplica - Supply Air 11
1310430 | Nivel 3 | Mechanical No Aplica - Supply Air 13
1310437 | Nivel 3 | Mechanical No Aplica - Supply Air 15
1310444 | Nivel 3 | Mechanical No Aplica - Supply Air 17
1310451 | Nivel 3 | Mechanical No Aplica - Supply Air 19
1310468 | Nivel 4 | Mechanical No Aplica - Supply Air 21
1310475 | Nivel 4 | Mechanical No Aplica - Supply Air 23
1310482 | Nivel 4 | Mechanical No Aplica - Supply Air 25
1310489 | Nivel 4 | Mechanical No Aplica - Supply Air 27
1310506 | Nivel 5 | Mechanical No Aplica - Supply Air 29
1310513 | Nivel 5 | Mechanical No Aplica - Supply Air 31
1310520 | Nivel 5 | Mechanical No Aplica - Supply Air 33
1310527 | Nivel 5 | Mechanical No Aplica - Supply Air 35
1310544 | Nivel 6 | Mechanical No Aplica - Supply Air 37
1310551 | Nivel 6 | Mechanical No Aplica - Supply Air 39
1310558 | Nivel 6 | Mechanical No Aplica - Supply Air 41
1310565 | Nivel 6 | Mechanical No Aplica - Supply Air 43

# IfcDuctSegment: Round Duct:Taps / Short Radius (48)
Classification: 21.04.30.50.50 Uniformat (Uniformat)
Pset_DuctSegmentTypeCommon - Reference: Taps / Short Radius; sets with these values: 2
Qto_DuctSegmentBaseQuantities - GrossCrossSectionArea: 0.0044172 m2; NetCrossSectionArea: 0.0044172 m2
Name (Round Duct:Taps / Short Radius:...) | In | Length (m) | OuterSurfaceArea (m2) | Group
1307662 | Nivel 2 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 1
1307664 | Nivel 2 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 1
1310311 | Nivel 2 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 2
1310313 | Nivel 2 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 2
1310325 | Nivel 2 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 3
1310327 | Nivel 2 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 3
1310359 | Nivel 2 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 4
1310361 | Nivel 2 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 4
1310388 | Nivel 1 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 5
1310390 | Nivel 1 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 5
1310395 | Nivel 1 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 7
1310397 | Nivel 1 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 7
1310402 | Nivel 1 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 9
1310404 | Nivel 1 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 9
1310409 | Nivel 1 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 11
1310411 | Nivel 1 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 11
1310426 | Nivel 3 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 13
1310428 | Nivel 3 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 13
1310433 | Nivel 3 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 15
1310435 | Nivel 3 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 15
1310440 | Nivel 3 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 17
1310442 | Nivel 3 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 17
1310447 | Nivel 3 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 19
1310449 | Nivel 3 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 19
1310464 | Nivel 4 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 21
1310466 | Nivel 4 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 21
1310471 | Nivel 4 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 23
1310473 | Nivel 4 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 23
1310478 | Nivel 4 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 25
1310480 | Nivel 4 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 25
1310485 | Nivel 4 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 27
1310487 | Nivel 4 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 27
1310502 | Nivel 5 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 29
1310504 | Nivel 5 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 29
1310509 | Nivel 5 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 31
1310511 | Nivel 5 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 31
1310516 | Nivel 5 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 33
1310518 | Nivel 5 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 33
1310523 | Nivel 5 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 35
1310525 | Nivel 5 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 35
1310540 | Nivel 6 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 37
1310542 | Nivel 6 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 37
1310547 | Nivel 6 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 39
1310549 | Nivel 6 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 39
1310554 | Nivel 6 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 41
1310556 | Nivel 6 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 41
1310561 | Nivel 6 | 0.2289 | 0.0539333 | Mechanical No Aplica - Supply Air 43
1310563 | Nivel 6 | 0.715719 | 0.168637 | Mechanical No Aplica - Supply Air 43

# IfcOpeningElement (6)
PredefinedType: OPENING; Classification: 21.04.20.60.30 Uniformat (Uniformat)
Qto_OpeningElementBaseQuantities - Depth: 0.05 m; Height: 1.022 m; Width: 0.26 m
Pset_EnvironmentalImpactIndicators - Reference: D2060 - CAJILLA REG 2DA ETAPA Y 4 MED 1.6; sets with these values: 2
Name (D2060 - CAJILLA REG 2DA ETAPA Y 4 MED 1.6:D2060 - CAJILLA REG 2DA ETAPA Y 4 MED 1.6:...) | In
1054598:1 | Nivel 1
1191990:1 | Nivel 2
1192348:1 | Nivel 3
1192706:1 | Nivel 4
1193064:1 | Nivel 5
1193422:1 | Nivel 6

# IfcPipeFitting: Coupling - PVC - Sch 40 - DWV:Standard (4)
Type - Material: <Unnamed>
Classification: 21.04.20.20.30 Uniformat (Uniformat); Group: AR-DOM 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Qto_PipeFittingBaseQuantities - Length: 0.09525 m
Name (Coupling - PVC - Sch 40 - DWV:Standard:...) | In
1223691 | Nivel 6
1223772 | Nivel 6
1223861 | Nivel 5
1224034 | Nivel 5

# IfcPipeFitting: D2010 - Buje Soldado PVC.F:Standard (3)
In: Nivel 1
Type - Material: PVC agua fria PAVCO
Classification: 21.04.40.10.10 Uniformat (Uniformat); Group: RCI 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2010 - Buje Soldado PVC.F:Standard:...) | Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2)
1207624 | 0.003378 | 0.00043073 | 0.00186457
1208338 | 0.006366 | 0.00153418 | 0.00463009
1208341 | 0.006366 | 0.00153418 | 0.00463009

# IfcPipeFitting: D2010 - Buje Soldado PVC.P:Standard (85)
Type - Material: PVC agua fria PAVCO
Classification: 21.04.20.10.40 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2010 - Buje Soldado PVC.P:Standard:...) | In | Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Group
1061236 | Nivel 6 | 0.00415 | 0.000639646 | 0.00244416 | AF 2
1061238 | Nivel 6 | 0.00415 | 0.000639646 | 0.00244416 | AF 2
1061269 | Nivel 5 | 0.00415 | 0.000639646 | 0.00244416 | AF 2
1061318 | Nivel 4 | 0.004892 | 0.000896089 | 0.00309964 | AF 2
1061320 | Nivel 4 | 0.004892 | 0.000896089 | 0.00309964 | AF 2
1061358 | Nivel 1 | 0.0076 | 0.003428 | 0.00855791 | AF 2
1061360 | Nivel 3 | 0.006366 | 0.00153418 | 0.00463009 | AF 2
1061362 | Nivel 3 | 0.006366 | 0.00153418 | 0.00463009 | AF 2
1061394 | Nivel 2 | 0.006366 | 0.00153418 | 0.00463009 | AF 2
1062403 | Nivel 1 | 0.002629 | 0.000259264 | 0.00105443 | AF 2
1107881 | Nivel 1 | 0.0076 | 0.003428 | 0.00855791 | AF 2
1110042 | Nivel 2 | 0.0027 | 0.000259264 | 0.00126438 | AF 1
1110154 | Nivel 2 | 0.0027 | 0.000259264 | 0.00126438 | AF 1
1110201 | Nivel 2 | 0.0027 | 0.000259264 | 0.00126438 | AF 16
1110309 | Nivel 2 | 0.0027 | 0.000259264 | 0.00126438 | AF 16
1110328 | Nivel 2 | 0.0027 | 0.000259264 | 0.00126438 | AF 16
1110366 | Nivel 2 | 0.0027 | 0.000259264 | 0.00126438 | AF 30
1110478 | Nivel 2 | 0.0027 | 0.000259264 | 0.00126438 | AF 30
1110497 | Nivel 2 | 0.0027 | 0.000259264 | 0.00126438 | AF 30
1110527 | Nivel 2 | 0.0027 | 0.000259264 | 0.00126438 | AF 44
1110635 | Nivel 2 | 0.0027 | 0.000259264 | 0.00126438 | AF 44
1110825 | Nivel 2 | 0.0027 | 0.000259264 | 0.00126438 | AF 44
1111063 | Nivel 2 | 0.0027 | 0.000259264 | 0.00126438 | AF 1
1112776 | Nivel 1 | 0.0027 | 0.000259264 | 0.00126438 | AF 3
1112888 | Nivel 1 | 0.0027 | 0.000259264 | 0.00126438 | AF 3
1112935 | Nivel 1 | 0.0027 | 0.000259264 | 0.00126438 | AF 17
1113043 | Nivel 1 | 0.0027 | 0.000259264 | 0.00126438 | AF 17
1113062 | Nivel 1 | 0.0027 | 0.000259264 | 0.00126438 | AF 17
1113100 | Nivel 1 | 0.0027 | 0.000259264 | 0.00126438 | AF 31
1113212 | Nivel 1 | 0.0027 | 0.000259264 | 0.00126438 | AF 31
1113231 | Nivel 1 | 0.0027 | 0.000259264 | 0.00126438 | AF 31
1113261 | Nivel 1 | 0.0027 | 0.000259264 | 0.00126438 | AF 45
1113369 | Nivel 1 | 0.0027 | 0.000259264 | 0.00126438 | AF 45
1113460 | Nivel 1 | 0.0027 | 0.000259264 | 0.00126438 | AF 45
1113468 | Nivel 1 | 0.0027 | 0.000259264 | 0.00126438 | AF 3
1113951 | Nivel 3 | 0.0027 | 0.000259264 | 0.00126438 | AF 4
1114063 | Nivel 3 | 0.0027 | 0.000259264 | 0.00126438 | AF 4
1114110 | Nivel 3 | 0.0027 | 0.000259264 | 0.00126438 | AF 19
1114218 | Nivel 3 | 0.0027 | 0.000259264 | 0.00126438 | AF 19
1114237 | Nivel 3 | 0.0027 | 0.000259264 | 0.00126438 | AF 19
1114275 | Nivel 3 | 0.0027 | 0.000259264 | 0.00126438 | AF 34
1114387 | Nivel 3 | 0.0027 | 0.000259264 | 0.00126438 | AF 34
1114406 | Nivel 3 | 0.0027 | 0.000259264 | 0.00126438 | AF 34
1114436 | Nivel 3 | 0.0027 | 0.000259264 | 0.00126438 | AF 49
1114544 | Nivel 3 | 0.0027 | 0.000259264 | 0.00126438 | AF 49
1114635 | Nivel 3 | 0.0027 | 0.000259264 | 0.00126438 | AF 49
1114643 | Nivel 3 | 0.0027 | 0.000259264 | 0.00126438 | AF 4
1115004 | Nivel 4 | 0.0027 | 0.000259264 | 0.00126438 | AF 5
1115116 | Nivel 4 | 0.0027 | 0.000259264 | 0.00126438 | AF 5
1115163 | Nivel 4 | 0.0027 | 0.000259264 | 0.00126438 | AF 21
1115271 | Nivel 4 | 0.0027 | 0.000259264 | 0.00126438 | AF 21
1115290 | Nivel 4 | 0.0027 | 0.000259264 | 0.00126438 | AF 21
1115328 | Nivel 4 | 0.0027 | 0.000259264 | 0.00126438 | AF 37
1115440 | Nivel 4 | 0.0027 | 0.000259264 | 0.00126438 | AF 37
1115459 | Nivel 4 | 0.0027 | 0.000259264 | 0.00126438 | AF 37
1115489 | Nivel 4 | 0.0027 | 0.000259264 | 0.00126438 | AF 53
1115597 | Nivel 4 | 0.0027 | 0.000259264 | 0.00126438 | AF 53
1115688 | Nivel 4 | 0.0027 | 0.000259264 | 0.00126438 | AF 53
1115696 | Nivel 4 | 0.0027 | 0.000259264 | 0.00126438 | AF 5
1116057 | Nivel 5 | 0.0027 | 0.000259264 | 0.00126438 | AF 6
1116169 | Nivel 5 | 0.0027 | 0.000259264 | 0.00126438 | AF 6
1116216 | Nivel 5 | 0.0027 | 0.000259264 | 0.00126438 | AF 23
1116324 | Nivel 5 | 0.0027 | 0.000259264 | 0.00126438 | AF 23
1116343 | Nivel 5 | 0.0027 | 0.000259264 | 0.00126438 | AF 23
1116381 | Nivel 5 | 0.0027 | 0.000259264 | 0.00126438 | AF 40
1116493 | Nivel 5 | 0.0027 | 0.000259264 | 0.00126438 | AF 40
1116512 | Nivel 5 | 0.0027 | 0.000259264 | 0.00126438 | AF 40
1116542 | Nivel 5 | 0.0027 | 0.000259264 | 0.00126438 | AF 57
1116650 | Nivel 5 | 0.0027 | 0.000259264 | 0.00126438 | AF 57
1116741 | Nivel 5 | 0.0027 | 0.000259264 | 0.00126438 | AF 57
1116749 | Nivel 5 | 0.0027 | 0.000259264 | 0.00126438 | AF 6
1117098 | Nivel 6 | 0.0027 | 0.000259264 | 0.00126438 | AF 7
1117210 | Nivel 6 | 0.0027 | 0.000259264 | 0.00126438 | AF 7
1117257 | Nivel 6 | 0.0027 | 0.000259264 | 0.00126438 | AC 16
1117365 | Nivel 6 | 0.0027 | 0.000259264 | 0.00126438 | AC 16
1117384 | Nivel 6 | 0.0027 | 0.000259264 | 0.00126438 | AC 16
1117422 | Nivel 6 | 0.0027 | 0.000259264 | 0.00126438 | AF 43
1117534 | Nivel 6 | 0.0027 | 0.000259264 | 0.00126438 | AF 43
1117553 | Nivel 6 | 0.0027 | 0.000259264 | 0.00126438 | AF 43
1117583 | Nivel 6 | 0.0027 | 0.000259264 | 0.00126438 | AF 61
1117691 | Nivel 6 | 0.0027 | 0.000259264 | 0.00126438 | AF 61
1117782 | Nivel 6 | 0.0027 | 0.000259264 | 0.00126438 | AF 61
1117790 | Nivel 6 | 0.0027 | 0.000259264 | 0.00126438 | AF 7
1198578 | Nivel 1 | 0.0076 | 0.003428 | 0.00855791 | AF 2
1198581 | Nivel 1 | 0.0076 | 0.003428 | 0.00855791 | AF 2

# IfcPipeFitting: D2010 - Codo CPVC.P:Standard (264)
Type - Material: CPVC
Classification: 21.04.20.10.40 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2010 - Codo CPVC.P:Standard:...) | In | Group
958859 | Nivel 2 | AC 1
959250 | Nivel 2 | AC 1
959309 | Nivel 2 | AC 1
959313 | Nivel 2 | AC 1
963071 | Nivel 2 | AC 1
963232 | Nivel 2 | AC 1
965246 | Nivel 2 | AC 1
965254 | Nivel 2 | AC 1
965312 | Nivel 2 | AC 1
965314 | Nivel 2 | AC 1
1063788 | Nivel 2 | AC 2
1063808 | Nivel 2 | AC 2
1063812 | Nivel 2 | AC 2
1063814 | Nivel 2 | AC 2
1063915 | Nivel 2 | AC 2
1063935 | Nivel 2 | AC 2
1065525 | Nivel 2 | AC 4
1065533 | Nivel 2 | AC 4
1065537 | Nivel 2 | AC 4
1065539 | Nivel 2 | AC 4
1065545 | Nivel 2 | AC 4
1065552 | Nivel 2 | AC 4
1065564 | Nivel 2 | AC 4
1065568 | Nivel 2 | AC 4
1065572 | Nivel 2 | AC 4
1065574 | Nivel 2 | AC 4
1066288 | Nivel 2 | AC 2
1066296 | Nivel 2 | AC 2
1066310 | Nivel 2 | AC 2
1066312 | Nivel 2 | AC 2
1066480 | Nivel 2 | AC 5
1066488 | Nivel 2 | AC 5
1066492 | Nivel 2 | AC 5
1066494 | Nivel 2 | AC 5
1066500 | Nivel 2 | AC 5
1066519 | Nivel 2 | AC 5
1066535 | Nivel 2 | AC 5
1066539 | Nivel 2 | AC 5
1066543 | Nivel 2 | AC 5
1066545 | Nivel 2 | AC 5
1066753 | Nivel 2 | AC 2
1066757 | Nivel 2 | AC 2
1066792 | Nivel 2 | AC 5
1066796 | Nivel 2 | AC 5
1106416 | Nivel 1 | AC 3
1106424 | Nivel 1 | AC 3
1106428 | Nivel 1 | AC 3
1106430 | Nivel 1 | AC 3
1106436 | Nivel 1 | AC 3
1106443 | Nivel 1 | AC 3
1106455 | Nivel 1 | AC 3
1106459 | Nivel 1 | AC 3
1106463 | Nivel 1 | AC 3
1106465 | Nivel 1 | AC 3
1106471 | Nivel 1 | AC 8
1106479 | Nivel 1 | AC 8
1106483 | Nivel 1 | AC 8
1106485 | Nivel 1 | AC 8
1106491 | Nivel 1 | AC 8
1106506 | Nivel 1 | AC 8
1106514 | Nivel 1 | AC 11
1106522 | Nivel 1 | AC 11
1106526 | Nivel 1 | AC 11
1106528 | Nivel 1 | AC 11
1106534 | Nivel 1 | AC 11
1106541 | Nivel 1 | AC 11
1106553 | Nivel 1 | AC 11
1106557 | Nivel 1 | AC 11
1106561 | Nivel 1 | AC 11
1106563 | Nivel 1 | AC 11
1106569 | Nivel 1 | AC 8
1106573 | Nivel 1 | AC 8
1106577 | Nivel 1 | AC 8
1106579 | Nivel 1 | AC 8
1106585 | Nivel 1 | AC 14
1106593 | Nivel 1 | AC 14
1106597 | Nivel 1 | AC 14
1106599 | Nivel 1 | AC 14
1106605 | Nivel 1 | AC 14
1106622 | Nivel 1 | AC 14
1106628 | Nivel 1 | AC 14
1106632 | Nivel 1 | AC 14
1106636 | Nivel 1 | AC 14
1106638 | Nivel 1 | AC 14
1106640 | Nivel 1 | AC 8
1106642 | Nivel 1 | AC 8
1106644 | Nivel 1 | AC 14
1106646 | Nivel 1 | AC 14
1113693 | Nivel 3 | AC 6
1113701 | Nivel 3 | AC 6
1113705 | Nivel 3 | AC 6
1113707 | Nivel 3 | AC 6
1113713 | Nivel 3 | AC 6
1113720 | Nivel 3 | AC 6
1113732 | Nivel 3 | AC 6
1113736 | Nivel 3 | AC 6
1113740 | Nivel 3 | AC 6
1113742 | Nivel 3 | AC 6
1113748 | Nivel 3 | AC 10
1113756 | Nivel 3 | AC 10
1113760 | Nivel 3 | AC 10
1113762 | Nivel 3 | AC 10
1113768 | Nivel 3 | AC 10
1113783 | Nivel 3 | AC 10
1113791 | Nivel 3 | AC 15
1113799 | Nivel 3 | AC 15
1113803 | Nivel 3 | AC 15
1113805 | Nivel 3 | AC 15
1113811 | Nivel 3 | AC 15
1113818 | Nivel 3 | AC 15
1113830 | Nivel 3 | AC 15
1113834 | Nivel 3 | AC 15
1113838 | Nivel 3 | AC 15
1113840 | Nivel 3 | AC 15
1113846 | Nivel 3 | AC 10
1113850 | Nivel 3 | AC 10
1113854 | Nivel 3 | AC 10
1113856 | Nivel 3 | AC 10
1113862 | Nivel 3 | AC 18
1113870 | Nivel 3 | AC 18
1113874 | Nivel 3 | AC 18
1113876 | Nivel 3 | AC 18
1113882 | Nivel 3 | AC 18
1113899 | Nivel 3 | AC 18
1113905 | Nivel 3 | AC 18
1113909 | Nivel 3 | AC 18
1113913 | Nivel 3 | AC 18
1113915 | Nivel 3 | AC 18
1113917 | Nivel 3 | AC 10
1113919 | Nivel 3 | AC 10
1113921 | Nivel 3 | AC 18
1113923 | Nivel 3 | AC 18
1114746 | Nivel 4 | AC 7
1114754 | Nivel 4 | AC 7
1114758 | Nivel 4 | AC 7
1114760 | Nivel 4 | AC 7
1114766 | Nivel 4 | AC 7
1114773 | Nivel 4 | AC 7
1114785 | Nivel 4 | AC 7
1114789 | Nivel 4 | AC 7
1114793 | Nivel 4 | AC 7
1114795 | Nivel 4 | AC 7
1114801 | Nivel 4 | AC 13
1114809 | Nivel 4 | AC 13
1114813 | Nivel 4 | AC 13
1114815 | Nivel 4 | AC 13
1114821 | Nivel 4 | AC 13
1114836 | Nivel 4 | AC 13
1114844 | Nivel 4 | AC 19
1114852 | Nivel 4 | AC 19
1114856 | Nivel 4 | AC 19
1114858 | Nivel 4 | AC 19
1114864 | Nivel 4 | AC 19
1114871 | Nivel 4 | AC 19
1114883 | Nivel 4 | AC 19
1114887 | Nivel 4 | AC 19
1114891 | Nivel 4 | AC 19
1114893 | Nivel 4 | AC 19
1114899 | Nivel 4 | AC 13
1114903 | Nivel 4 | AC 13
1114907 | Nivel 4 | AC 13
1114909 | Nivel 4 | AC 13
1114915 | Nivel 4 | AC 22
1114923 | Nivel 4 | AC 22
1114927 | Nivel 4 | AC 22
1114929 | Nivel 4 | AC 22
1114935 | Nivel 4 | AC 22
1114952 | Nivel 4 | AC 22
1114958 | Nivel 4 | AC 22
1114962 | Nivel 4 | AC 22
1114966 | Nivel 4 | AC 22
1114968 | Nivel 4 | AC 22
1114970 | Nivel 4 | AC 13
1114972 | Nivel 4 | AC 13
1114974 | Nivel 4 | AC 22
1114976 | Nivel 4 | AC 22
1115799 | Nivel 5 | AC 9
1115807 | Nivel 5 | AC 9
1115811 | Nivel 5 | AC 9
1115813 | Nivel 5 | AC 9
1115819 | Nivel 5 | AC 9
1115826 | Nivel 5 | AC 9
1115838 | Nivel 5 | AC 9
1115842 | Nivel 5 | AC 9
1115846 | Nivel 5 | AC 9
1115848 | Nivel 5 | AC 9
1115854 | Nivel 5 | AC 17
1115862 | Nivel 5 | AC 17
1115866 | Nivel 5 | AC 17
1115868 | Nivel 5 | AC 17
1115874 | Nivel 5 | AC 17
1115889 | Nivel 5 | AC 17
1115897 | Nivel 5 | AC 23
1115905 | Nivel 5 | AC 23
1115909 | Nivel 5 | AC 23
1115911 | Nivel 5 | AC 23
1115917 | Nivel 5 | AC 23
1115924 | Nivel 5 | AC 23
1115936 | Nivel 5 | AC 23
1115940 | Nivel 5 | AC 23
1115944 | Nivel 5 | AC 23
1115946 | Nivel 5 | AC 23
1115952 | Nivel 5 | AC 17
1115956 | Nivel 5 | AC 17
1115960 | Nivel 5 | AC 17
1115962 | Nivel 5 | AC 17
1115968 | Nivel 5 | AC 26
1115976 | Nivel 5 | AC 26
1115980 | Nivel 5 | AC 26
1115982 | Nivel 5 | AC 26
1115988 | Nivel 5 | AC 26
1116005 | Nivel 5 | AC 26
1116011 | Nivel 5 | AC 26
1116015 | Nivel 5 | AC 26
1116019 | Nivel 5 | AC 26
1116021 | Nivel 5 | AC 26
1116023 | Nivel 5 | AC 17
1116025 | Nivel 5 | AC 17
1116027 | Nivel 5 | AC 26
1116029 | Nivel 5 | AC 26
1116840 | Nivel 6 | AC 12
1116848 | Nivel 6 | AC 12
1116852 | Nivel 6 | AC 12
1116854 | Nivel 6 | AC 12
1116860 | Nivel 6 | AC 12
1116867 | Nivel 6 | AC 12
1116879 | Nivel 6 | AC 12
1116883 | Nivel 6 | AC 12
1116887 | Nivel 6 | AC 12
1116889 | Nivel 6 | AC 12
1116895 | Nivel 6 | AC 21
1116903 | Nivel 6 | AC 21
1116907 | Nivel 6 | AC 21
1116909 | Nivel 6 | AC 21
1116915 | Nivel 6 | AC 21
1116930 | Nivel 6 | AC 21
1116938 | Nivel 6 | AC 27
1116946 | Nivel 6 | AC 27
1116950 | Nivel 6 | AC 27
1116952 | Nivel 6 | AC 27
1116958 | Nivel 6 | AC 27
1116965 | Nivel 6 | AC 27
1116977 | Nivel 6 | AC 27
1116981 | Nivel 6 | AC 27
1116985 | Nivel 6 | AC 27
1116987 | Nivel 6 | AC 27
1116993 | Nivel 6 | AC 21
1116997 | Nivel 6 | AC 21
1117001 | Nivel 6 | AC 21
1117003 | Nivel 6 | AC 21
1117009 | Nivel 6 | AC 30
1117017 | Nivel 6 | AC 30
1117021 | Nivel 6 | AC 30
1117023 | Nivel 6 | AC 30
1117029 | Nivel 6 | AC 30
1117046 | Nivel 6 | AC 30
1117052 | Nivel 6 | AC 30
1117056 | Nivel 6 | AC 30
1117060 | Nivel 6 | AC 30
1117062 | Nivel 6 | AC 30
1117064 | Nivel 6 | AC 21
1117066 | Nivel 6 | AC 21
1117068 | Nivel 6 | AC 30
1117070 | Nivel 6 | AC 30

# IfcPipeFitting: D2010 - Codo PVC.P:Standard (458)
Type - Material: PVC.P
Classification: 21.04.20.10.40 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2010 - Codo PVC.P:Standard:...) | In | Group
1055069 | Nivel 1 | AF 2
1056349 | Nivel 1 | AF 2
1110018 | Nivel 2 | AF 1
1110022 | Nivel 2 | AF 1
1110066 | Nivel 2 | AF 1
1110068 | Nivel 2 | AF 1
1110074 | Nivel 2 | AF 1
1110080 | Nivel 2 | AF 1
1110094 | Nivel 2 | AF 1
1110108 | Nivel 2 | AF 1
1110134 | Nivel 2 | AF 1
1110136 | Nivel 2 | AF 1
1110138 | Nivel 2 | AF 1
1110152 | Nivel 2 | AF 1
1110168 | Nivel 2 | AF 1
1110177 | Nivel 2 | AF 16
1110181 | Nivel 2 | AF 16
1110221 | Nivel 2 | AF 16
1110223 | Nivel 2 | AF 16
1110229 | Nivel 2 | AF 16
1110235 | Nivel 2 | AF 16
1110249 | Nivel 2 | AF 16
1110263 | Nivel 2 | AF 16
1110289 | Nivel 2 | AF 16
1110291 | Nivel 2 | AF 16
1110293 | Nivel 2 | AF 16
1110307 | Nivel 2 | AF 16
1110323 | Nivel 2 | AF 16
1110336 | Nivel 2 | AF 16
1110342 | Nivel 2 | AF 30
1110346 | Nivel 2 | AF 30
1110390 | Nivel 2 | AF 30
1110392 | Nivel 2 | AF 30
1110398 | Nivel 2 | AF 30
1110404 | Nivel 2 | AF 30
1110418 | Nivel 2 | AF 30
1110432 | Nivel 2 | AF 30
1110458 | Nivel 2 | AF 30
1110460 | Nivel 2 | AF 30
1110462 | Nivel 2 | AF 30
1110476 | Nivel 2 | AF 30
1110492 | Nivel 2 | AF 30
1110503 | Nivel 2 | AF 44
1110507 | Nivel 2 | AF 44
1110547 | Nivel 2 | AF 44
1110549 | Nivel 2 | AF 44
1110555 | Nivel 2 | AF 44
1110561 | Nivel 2 | AF 44
1110575 | Nivel 2 | AF 44
1110589 | Nivel 2 | AF 44
1110615 | Nivel 2 | AF 44
1110617 | Nivel 2 | AF 44
1110619 | Nivel 2 | AF 44
1110633 | Nivel 2 | AF 44
1110649 | Nivel 2 | AF 44
1110660 | Nivel 2 | AF 44
1110666 | Nivel 2 | AF 1
1110672 | Nivel 2 | AF 16
1110674 | Nivel 2 | AF 30
1110678 | Nivel 2 | AF 44
1110682 | Nivel 2 | AF 44
1110686 | Nivel 2 | AF 44
1110690 | Nivel 2 | AF 44
1110694 | Nivel 2 | AF 44
1110698 | Nivel 2 | AF 1
1110702 | Nivel 2 | AF 1
1110706 | Nivel 2 | AF 16
1110710 | Nivel 2 | AF 16
1110714 | Nivel 2 | AF 30
1110718 | Nivel 2 | AF 30
1110782 | Nivel 2 | AF 44
1110797 | Nivel 2 | AF 44
1110999 | Nivel 2 | AF 1
1111061 | Nivel 2 | AF 1
1111214 | Nivel 2 | AF 16
1111216 | Nivel 2 | AF 16
1111478 | Nivel 2 | AF 30
1111480 | Nivel 2 | AF 30
1112752 | Nivel 1 | AF 3
1112756 | Nivel 1 | AF 3
1112800 | Nivel 1 | AF 3
1112802 | Nivel 1 | AF 3
1112808 | Nivel 1 | AF 3
1112814 | Nivel 1 | AF 3
1112828 | Nivel 1 | AF 3
1112842 | Nivel 1 | AF 3
1112868 | Nivel 1 | AF 3
1112870 | Nivel 1 | AF 3
1112872 | Nivel 1 | AF 3
1112886 | Nivel 1 | AF 3
1112902 | Nivel 1 | AF 3
1112911 | Nivel 1 | AF 17
1112915 | Nivel 1 | AF 17
1112955 | Nivel 1 | AF 17
1112957 | Nivel 1 | AF 17
1112963 | Nivel 1 | AF 17
1112969 | Nivel 1 | AF 17
1112983 | Nivel 1 | AF 17
1112997 | Nivel 1 | AF 17
1113023 | Nivel 1 | AF 17
1113025 | Nivel 1 | AF 17
1113027 | Nivel 1 | AF 17
1113041 | Nivel 1 | AF 17
1113057 | Nivel 1 | AF 17
1113070 | Nivel 1 | AF 17
1113076 | Nivel 1 | AF 31
1113080 | Nivel 1 | AF 31
1113124 | Nivel 1 | AF 31
1113126 | Nivel 1 | AF 31
1113132 | Nivel 1 | AF 31
1113138 | Nivel 1 | AF 31
1113152 | Nivel 1 | AF 31
1113166 | Nivel 1 | AF 31
1113192 | Nivel 1 | AF 31
1113194 | Nivel 1 | AF 31
1113196 | Nivel 1 | AF 31
1113210 | Nivel 1 | AF 31
1113226 | Nivel 1 | AF 31
1113237 | Nivel 1 | AF 45
1113241 | Nivel 1 | AF 45
1113281 | Nivel 1 | AF 45
1113283 | Nivel 1 | AF 45
1113289 | Nivel 1 | AF 45
1113295 | Nivel 1 | AF 45
1113309 | Nivel 1 | AF 45
1113323 | Nivel 1 | AF 45
1113349 | Nivel 1 | AF 45
1113351 | Nivel 1 | AF 45
1113353 | Nivel 1 | AF 45
1113367 | Nivel 1 | AF 45
1113383 | Nivel 1 | AF 45
1113394 | Nivel 1 | AF 45
1113400 | Nivel 1 | AF 3
1113406 | Nivel 1 | AF 17
1113408 | Nivel 1 | AF 31
1113412 | Nivel 1 | AF 45
1113416 | Nivel 1 | AF 45
1113420 | Nivel 1 | AF 45
1113424 | Nivel 1 | AF 45
1113428 | Nivel 1 | AF 45
1113432 | Nivel 1 | AF 3
1113436 | Nivel 1 | AF 3
1113440 | Nivel 1 | AF 17
1113444 | Nivel 1 | AF 17
1113448 | Nivel 1 | AF 31
1113452 | Nivel 1 | AF 31
1113456 | Nivel 1 | AF 45
1113458 | Nivel 1 | AF 45
1113464 | Nivel 1 | AF 3
1113466 | Nivel 1 | AF 3
1113472 | Nivel 1 | AF 17
1113474 | Nivel 1 | AF 17
1113478 | Nivel 1 | AF 31
1113480 | Nivel 1 | AF 31
1113927 | Nivel 3 | AF 4
1113931 | Nivel 3 | AF 4
1113975 | Nivel 3 | AF 4
1113977 | Nivel 3 | AF 4
1113983 | Nivel 3 | AF 4
1113989 | Nivel 3 | AF 4
1114003 | Nivel 3 | AF 4
1114017 | Nivel 3 | AF 4
1114043 | Nivel 3 | AF 4
1114045 | Nivel 3 | AF 4
1114047 | Nivel 3 | AF 4
1114061 | Nivel 3 | AF 4
1114077 | Nivel 3 | AF 4
1114086 | Nivel 3 | AF 19
1114090 | Nivel 3 | AF 19
1114130 | Nivel 3 | AF 19
1114132 | Nivel 3 | AF 19
1114138 | Nivel 3 | AF 19
1114144 | Nivel 3 | AF 19
1114158 | Nivel 3 | AF 19
1114172 | Nivel 3 | AF 19
1114198 | Nivel 3 | AF 19
1114200 | Nivel 3 | AF 19
1114202 | Nivel 3 | AF 19
1114216 | Nivel 3 | AF 19
1114232 | Nivel 3 | AF 19
1114245 | Nivel 3 | AF 19
1114251 | Nivel 3 | AF 34
1114255 | Nivel 3 | AF 34
1114299 | Nivel 3 | AF 34
1114301 | Nivel 3 | AF 34
1114307 | Nivel 3 | AF 34
1114313 | Nivel 3 | AF 34
1114327 | Nivel 3 | AF 34
1114341 | Nivel 3 | AF 34
1114367 | Nivel 3 | AF 34
1114369 | Nivel 3 | AF 34
1114371 | Nivel 3 | AF 34
1114385 | Nivel 3 | AF 34
1114401 | Nivel 3 | AF 34
1114412 | Nivel 3 | AF 49
1114416 | Nivel 3 | AF 49
1114456 | Nivel 3 | AF 49
1114458 | Nivel 3 | AF 49
1114464 | Nivel 3 | AF 49
1114470 | Nivel 3 | AF 49
1114484 | Nivel 3 | AF 49
1114498 | Nivel 3 | AF 49
1114524 | Nivel 3 | AF 49
1114526 | Nivel 3 | AF 49
1114528 | Nivel 3 | AF 49
1114542 | Nivel 3 | AF 49
1114558 | Nivel 3 | AF 49
1114569 | Nivel 3 | AF 49
1114575 | Nivel 3 | AF 4
1114581 | Nivel 3 | AF 19
1114583 | Nivel 3 | AF 34
1114587 | Nivel 3 | AF 49
1114591 | Nivel 3 | AF 49
1114595 | Nivel 3 | AF 49
1114599 | Nivel 3 | AF 49
1114603 | Nivel 3 | AF 49
1114607 | Nivel 3 | AF 4
1114611 | Nivel 3 | AF 4
1114615 | Nivel 3 | AF 19
1114619 | Nivel 3 | AF 19
1114623 | Nivel 3 | AF 34
1114627 | Nivel 3 | AF 34
1114631 | Nivel 3 | AF 49
1114633 | Nivel 3 | AF 49
1114639 | Nivel 3 | AF 4
1114641 | Nivel 3 | AF 4
1114647 | Nivel 3 | AF 19
1114649 | Nivel 3 | AF 19
1114653 | Nivel 3 | AF 34
1114655 | Nivel 3 | AF 34
1114980 | Nivel 4 | AF 5
1114984 | Nivel 4 | AF 5
1115028 | Nivel 4 | AF 5
1115030 | Nivel 4 | AF 5
1115036 | Nivel 4 | AF 5
1115042 | Nivel 4 | AF 5
1115056 | Nivel 4 | AF 5
1115070 | Nivel 4 | AF 5
1115096 | Nivel 4 | AF 5
1115098 | Nivel 4 | AF 5
1115100 | Nivel 4 | AF 5
1115114 | Nivel 4 | AF 5
1115130 | Nivel 4 | AF 5
1115139 | Nivel 4 | AF 21
1115143 | Nivel 4 | AF 21
1115183 | Nivel 4 | AF 21
1115185 | Nivel 4 | AF 21
1115191 | Nivel 4 | AF 21
1115197 | Nivel 4 | AF 21
1115211 | Nivel 4 | AF 21
1115225 | Nivel 4 | AF 21
1115251 | Nivel 4 | AF 21
1115253 | Nivel 4 | AF 21
1115255 | Nivel 4 | AF 21
1115269 | Nivel 4 | AF 21
1115285 | Nivel 4 | AF 21
1115298 | Nivel 4 | AF 21
1115304 | Nivel 4 | AF 37
1115308 | Nivel 4 | AF 37
1115352 | Nivel 4 | AF 37
1115354 | Nivel 4 | AF 37
1115360 | Nivel 4 | AF 37
1115366 | Nivel 4 | AF 37
1115380 | Nivel 4 | AF 37
1115394 | Nivel 4 | AF 37
1115420 | Nivel 4 | AF 37
1115422 | Nivel 4 | AF 37
1115424 | Nivel 4 | AF 37
1115438 | Nivel 4 | AF 37
1115454 | Nivel 4 | AF 37
1115465 | Nivel 4 | AF 53
1115469 | Nivel 4 | AF 53
1115509 | Nivel 4 | AF 53
1115511 | Nivel 4 | AF 53
1115517 | Nivel 4 | AF 53
1115523 | Nivel 4 | AF 53
1115537 | Nivel 4 | AF 53
1115551 | Nivel 4 | AF 53
1115577 | Nivel 4 | AF 53
1115579 | Nivel 4 | AF 53
1115581 | Nivel 4 | AF 53
1115595 | Nivel 4 | AF 53
1115611 | Nivel 4 | AF 53
1115622 | Nivel 4 | AF 53
1115628 | Nivel 4 | AF 5
1115634 | Nivel 4 | AF 21
1115636 | Nivel 4 | AF 37
1115640 | Nivel 4 | AF 53
1115644 | Nivel 4 | AF 53
1115648 | Nivel 4 | AF 53
1115652 | Nivel 4 | AF 53
1115656 | Nivel 4 | AF 53
1115660 | Nivel 4 | AF 5
1115664 | Nivel 4 | AF 5
1115668 | Nivel 4 | AF 21
1115672 | Nivel 4 | AF 21
1115676 | Nivel 4 | AF 37
1115680 | Nivel 4 | AF 37
1115684 | Nivel 4 | AF 53
1115686 | Nivel 4 | AF 53
1115692 | Nivel 4 | AF 5
1115694 | Nivel 4 | AF 5
1115700 | Nivel 4 | AF 21
1115702 | Nivel 4 | AF 21
1115706 | Nivel 4 | AF 37
1115708 | Nivel 4 | AF 37
1116033 | Nivel 5 | AF 6
1116037 | Nivel 5 | AF 6
1116081 | Nivel 5 | AF 6
1116083 | Nivel 5 | AF 6
1116089 | Nivel 5 | AF 6
1116095 | Nivel 5 | AF 6
1116109 | Nivel 5 | AF 6
1116123 | Nivel 5 | AF 6
1116149 | Nivel 5 | AF 6
1116151 | Nivel 5 | AF 6
1116153 | Nivel 5 | AF 6
1116167 | Nivel 5 | AF 6
1116183 | Nivel 5 | AF 6
1116192 | Nivel 5 | AF 23
1116196 | Nivel 5 | AF 23
1116236 | Nivel 5 | AF 23
1116238 | Nivel 5 | AF 23
1116244 | Nivel 5 | AF 23
1116250 | Nivel 5 | AF 23
1116264 | Nivel 5 | AF 23
1116278 | Nivel 5 | AF 23
1116304 | Nivel 5 | AF 23
1116306 | Nivel 5 | AF 23
1116308 | Nivel 5 | AF 23
1116322 | Nivel 5 | AF 23
1116338 | Nivel 5 | AF 23
1116351 | Nivel 5 | AF 23
1116357 | Nivel 5 | AF 40
1116361 | Nivel 5 | AF 40
1116405 | Nivel 5 | AF 40
1116407 | Nivel 5 | AF 40
1116413 | Nivel 5 | AF 40
1116419 | Nivel 5 | AF 40
1116433 | Nivel 5 | AF 40
1116447 | Nivel 5 | AF 40
1116473 | Nivel 5 | AF 40
1116475 | Nivel 5 | AF 40
1116477 | Nivel 5 | AF 40
1116491 | Nivel 5 | AF 40
1116507 | Nivel 5 | AF 40
1116518 | Nivel 5 | AF 57
1116522 | Nivel 5 | AF 57
1116562 | Nivel 5 | AF 57
1116564 | Nivel 5 | AF 57
1116570 | Nivel 5 | AF 57
1116576 | Nivel 5 | AF 57
1116590 | Nivel 5 | AF 57
1116604 | Nivel 5 | AF 57
1116630 | Nivel 5 | AF 57
1116632 | Nivel 5 | AF 57
1116634 | Nivel 5 | AF 57
1116648 | Nivel 5 | AF 57
1116664 | Nivel 5 | AF 57
1116675 | Nivel 5 | AF 57
1116681 | Nivel 5 | AF 6
1116687 | Nivel 5 | AF 23
1116689 | Nivel 5 | AF 40
1116693 | Nivel 5 | AF 57
1116697 | Nivel 5 | AF 57
1116701 | Nivel 5 | AF 57
1116705 | Nivel 5 | AF 57
1116709 | Nivel 5 | AF 57
1116713 | Nivel 5 | AF 6
1116717 | Nivel 5 | AF 6
1116721 | Nivel 5 | AF 23
1116725 | Nivel 5 | AF 23
1116729 | Nivel 5 | AF 40
1116733 | Nivel 5 | AF 40
1116737 | Nivel 5 | AF 57
1116739 | Nivel 5 | AF 57
1116745 | Nivel 5 | AF 6
1116747 | Nivel 5 | AF 6
1116753 | Nivel 5 | AF 23
1116755 | Nivel 5 | AF 23
1116759 | Nivel 5 | AF 40
1116761 | Nivel 5 | AF 40
1117074 | Nivel 6 | AF 7
1117078 | Nivel 6 | AF 7
1117122 | Nivel 6 | AF 7
1117124 | Nivel 6 | AF 7
1117130 | Nivel 6 | AF 7
1117136 | Nivel 6 | AF 7
1117150 | Nivel 6 | AF 7
1117164 | Nivel 6 | AF 7
1117190 | Nivel 6 | AF 7
1117192 | Nivel 6 | AF 7
1117194 | Nivel 6 | AF 7
1117208 | Nivel 6 | AF 7
1117224 | Nivel 6 | AF 7
1117233 | Nivel 6 | AC 16
1117237 | Nivel 6 | AC 16
1117277 | Nivel 6 | AC 16
1117279 | Nivel 6 | AC 16
1117285 | Nivel 6 | AC 16
1117291 | Nivel 6 | AC 16
1117305 | Nivel 6 | AC 16
1117319 | Nivel 6 | AC 16
1117345 | Nivel 6 | AC 16
1117347 | Nivel 6 | AC 16
1117349 | Nivel 6 | AC 16
1117363 | Nivel 6 | AC 16
1117379 | Nivel 6 | AC 16
1117392 | Nivel 6 | AC 16
1117398 | Nivel 6 | AF 43
1117402 | Nivel 6 | AF 43
1117446 | Nivel 6 | AF 43
1117448 | Nivel 6 | AF 43
1117454 | Nivel 6 | AF 43
1117460 | Nivel 6 | AF 43
1117474 | Nivel 6 | AF 43
1117488 | Nivel 6 | AF 43
1117514 | Nivel 6 | AF 43
1117516 | Nivel 6 | AF 43
1117518 | Nivel 6 | AF 43
1117532 | Nivel 6 | AF 43
1117548 | Nivel 6 | AF 43
1117559 | Nivel 6 | AF 61
1117563 | Nivel 6 | AF 61
1117603 | Nivel 6 | AF 61
1117605 | Nivel 6 | AF 61
1117611 | Nivel 6 | AF 61
1117617 | Nivel 6 | AF 61
1117631 | Nivel 6 | AF 61
1117645 | Nivel 6 | AF 61
1117671 | Nivel 6 | AF 61
1117673 | Nivel 6 | AF 61
1117675 | Nivel 6 | AF 61
1117689 | Nivel 6 | AF 61
1117705 | Nivel 6 | AF 61
1117716 | Nivel 6 | AF 61
1117722 | Nivel 6 | AF 7
1117728 | Nivel 6 | AC 16
1117730 | Nivel 6 | AF 43
1117734 | Nivel 6 | AF 61
1117738 | Nivel 6 | AF 61
1117742 | Nivel 6 | AF 61
1117746 | Nivel 6 | AF 61
1117750 | Nivel 6 | AF 61
1117754 | Nivel 6 | AF 7
1117758 | Nivel 6 | AF 7
1117762 | Nivel 6 | AC 16
1117766 | Nivel 6 | AC 16
1117770 | Nivel 6 | AF 43
1117774 | Nivel 6 | AF 43
1117778 | Nivel 6 | AF 61
1117780 | Nivel 6 | AF 61
1117786 | Nivel 6 | AF 7
1117788 | Nivel 6 | AF 7
1117794 | Nivel 6 | AC 16
1117796 | Nivel 6 | AC 16
1117800 | Nivel 6 | AF 43
1117802 | Nivel 6 | AF 43

# IfcPipeFitting: D2010 - Tapon CPVC.P:Standard (48)
Type - Material: CPVC
Classification: 21.04.20.10.40 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2010 - Tapon CPVC.P:Standard:...) | In | Group
959266 | Nivel 2 | AC 1
963359 | Nivel 2 | AC 1
1063810 | Nivel 2 | AC 2
1063928 | Nivel 2 | AC 2
1065535 | Nivel 2 | AC 4
1065558 | Nivel 2 | AC 4
1066490 | Nivel 2 | AC 5
1066513 | Nivel 2 | AC 5
1106426 | Nivel 1 | AC 3
1106449 | Nivel 1 | AC 3
1106481 | Nivel 1 | AC 8
1106502 | Nivel 1 | AC 8
1106524 | Nivel 1 | AC 11
1106547 | Nivel 1 | AC 11
1106595 | Nivel 1 | AC 14
1106616 | Nivel 1 | AC 14
1113703 | Nivel 3 | AC 6
1113726 | Nivel 3 | AC 6
1113758 | Nivel 3 | AC 10
1113779 | Nivel 3 | AC 10
1113801 | Nivel 3 | AC 15
1113824 | Nivel 3 | AC 15
1113872 | Nivel 3 | AC 18
1113893 | Nivel 3 | AC 18
1114756 | Nivel 4 | AC 7
1114779 | Nivel 4 | AC 7
1114811 | Nivel 4 | AC 13
1114832 | Nivel 4 | AC 13
1114854 | Nivel 4 | AC 19
1114877 | Nivel 4 | AC 19
1114925 | Nivel 4 | AC 22
1114946 | Nivel 4 | AC 22
1115809 | Nivel 5 | AC 9
1115832 | Nivel 5 | AC 9
1115864 | Nivel 5 | AC 17
1115885 | Nivel 5 | AC 17
1115907 | Nivel 5 | AC 23
1115930 | Nivel 5 | AC 23
1115978 | Nivel 5 | AC 26
1115999 | Nivel 5 | AC 26
1116850 | Nivel 6 | AC 12
1116873 | Nivel 6 | AC 12
1116905 | Nivel 6 | AC 21
1116926 | Nivel 6 | AC 21
1116948 | Nivel 6 | AC 27
1116971 | Nivel 6 | AC 27
1117019 | Nivel 6 | AC 30
1117040 | Nivel 6 | AC 30

# IfcPipeFitting: D2010 - Tapon PVC.P:Standard (288)
Type - Material: PVC
Classification: 21.04.20.10.40 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Qto_PipeFittingBaseQuantities - Length: 0.0162775 m
Name (D2010 - Tapon PVC.P:Standard:...) | In | Group
1110076 | Nivel 2 | AF 1
1110086 | Nivel 2 | AF 1
1110092 | Nivel 2 | AF 1
1110100 | Nivel 2 | AF 1
1110106 | Nivel 2 | AF 1
1110114 | Nivel 2 | AF 1
1110120 | Nivel 2 | AF 1
1110126 | Nivel 2 | AF 1
1110132 | Nivel 2 | AF 1
1110144 | Nivel 2 | AF 1
1110150 | Nivel 2 | AF 1
1110164 | Nivel 2 | AF 1
1110231 | Nivel 2 | AF 16
1110241 | Nivel 2 | AF 16
1110247 | Nivel 2 | AF 16
1110255 | Nivel 2 | AF 16
1110261 | Nivel 2 | AF 16
1110269 | Nivel 2 | AF 16
1110275 | Nivel 2 | AF 16
1110281 | Nivel 2 | AF 16
1110287 | Nivel 2 | AF 16
1110299 | Nivel 2 | AF 16
1110305 | Nivel 2 | AF 16
1110319 | Nivel 2 | AF 16
1110400 | Nivel 2 | AF 30
1110410 | Nivel 2 | AF 30
1110416 | Nivel 2 | AF 30
1110424 | Nivel 2 | AF 30
1110430 | Nivel 2 | AF 30
1110438 | Nivel 2 | AF 30
1110444 | Nivel 2 | AF 30
1110450 | Nivel 2 | AF 30
1110456 | Nivel 2 | AF 30
1110468 | Nivel 2 | AF 30
1110474 | Nivel 2 | AF 30
1110488 | Nivel 2 | AF 30
1110557 | Nivel 2 | AF 44
1110567 | Nivel 2 | AF 44
1110573 | Nivel 2 | AF 44
1110581 | Nivel 2 | AF 44
1110587 | Nivel 2 | AF 44
1110595 | Nivel 2 | AF 44
1110601 | Nivel 2 | AF 44
1110607 | Nivel 2 | AF 44
1110613 | Nivel 2 | AF 44
1110625 | Nivel 2 | AF 44
1110631 | Nivel 2 | AF 44
1110645 | Nivel 2 | AF 44
1112810 | Nivel 1 | AF 3
1112820 | Nivel 1 | AF 3
1112826 | Nivel 1 | AF 3
1112834 | Nivel 1 | AF 3
1112840 | Nivel 1 | AF 3
1112848 | Nivel 1 | AF 3
1112854 | Nivel 1 | AF 3
1112866 | Nivel 1 | AF 3
1112878 | Nivel 1 | AF 3
1112884 | Nivel 1 | AF 3
1112898 | Nivel 1 | AF 3
1112965 | Nivel 1 | AF 17
1112975 | Nivel 1 | AF 17
1112981 | Nivel 1 | AF 17
1112989 | Nivel 1 | AF 17
1112995 | Nivel 1 | AF 17
1113003 | Nivel 1 | AF 17
1113009 | Nivel 1 | AF 17
1113015 | Nivel 1 | AF 17
1113021 | Nivel 1 | AF 17
1113033 | Nivel 1 | AF 17
1113039 | Nivel 1 | AF 17
1113053 | Nivel 1 | AF 17
1113134 | Nivel 1 | AF 31
1113144 | Nivel 1 | AF 31
1113150 | Nivel 1 | AF 31
1113158 | Nivel 1 | AF 31
1113164 | Nivel 1 | AF 31
1113172 | Nivel 1 | AF 31
1113178 | Nivel 1 | AF 31
1113184 | Nivel 1 | AF 31
1113190 | Nivel 1 | AF 31
1113202 | Nivel 1 | AF 31
1113208 | Nivel 1 | AF 31
1113222 | Nivel 1 | AF 31
1113291 | Nivel 1 | AF 45
1113301 | Nivel 1 | AF 45
1113307 | Nivel 1 | AF 45
1113315 | Nivel 1 | AF 45
1113321 | Nivel 1 | AF 45
1113329 | Nivel 1 | AF 45
1113335 | Nivel 1 | AF 45
1113341 | Nivel 1 | AF 45
1113347 | Nivel 1 | AF 45
1113359 | Nivel 1 | AF 45
1113365 | Nivel 1 | AF 45
1113379 | Nivel 1 | AF 45
1113985 | Nivel 3 | AF 4
1113995 | Nivel 3 | AF 4
1114001 | Nivel 3 | AF 4
1114009 | Nivel 3 | AF 4
1114015 | Nivel 3 | AF 4
1114023 | Nivel 3 | AF 4
1114029 | Nivel 3 | AF 4
1114035 | Nivel 3 | AF 4
1114041 | Nivel 3 | AF 4
1114053 | Nivel 3 | AF 4
1114059 | Nivel 3 | AF 4
1114073 | Nivel 3 | AF 4
1114140 | Nivel 3 | AF 19
1114150 | Nivel 3 | AF 19
1114156 | Nivel 3 | AF 19
1114164 | Nivel 3 | AF 19
1114170 | Nivel 3 | AF 19
1114178 | Nivel 3 | AF 19
1114184 | Nivel 3 | AF 19
1114190 | Nivel 3 | AF 19
1114196 | Nivel 3 | AF 19
1114208 | Nivel 3 | AF 19
1114214 | Nivel 3 | AF 19
1114228 | Nivel 3 | AF 19
1114309 | Nivel 3 | AF 34
1114319 | Nivel 3 | AF 34
1114325 | Nivel 3 | AF 34
1114333 | Nivel 3 | AF 34
1114339 | Nivel 3 | AF 34
1114347 | Nivel 3 | AF 34
1114353 | Nivel 3 | AF 34
1114359 | Nivel 3 | AF 34
1114365 | Nivel 3 | AF 34
1114377 | Nivel 3 | AF 34
1114383 | Nivel 3 | AF 34
1114397 | Nivel 3 | AF 34
1114466 | Nivel 3 | AF 49
1114476 | Nivel 3 | AF 49
1114482 | Nivel 3 | AF 49
1114490 | Nivel 3 | AF 49
1114496 | Nivel 3 | AF 49
1114504 | Nivel 3 | AF 49
1114510 | Nivel 3 | AF 49
1114516 | Nivel 3 | AF 49
1114522 | Nivel 3 | AF 49
1114534 | Nivel 3 | AF 49
1114540 | Nivel 3 | AF 49
1114554 | Nivel 3 | AF 49
1115038 | Nivel 4 | AF 5
1115048 | Nivel 4 | AF 5
1115054 | Nivel 4 | AF 5
1115062 | Nivel 4 | AF 5
1115068 | Nivel 4 | AF 5
1115076 | Nivel 4 | AF 5
1115082 | Nivel 4 | AF 5
1115088 | Nivel 4 | AF 5
1115094 | Nivel 4 | AF 5
1115106 | Nivel 4 | AF 5
1115112 | Nivel 4 | AF 5
1115126 | Nivel 4 | AF 5
1115193 | Nivel 4 | AF 21
1115203 | Nivel 4 | AF 21
1115209 | Nivel 4 | AF 21
1115217 | Nivel 4 | AF 21
1115223 | Nivel 4 | AF 21
1115231 | Nivel 4 | AF 21
1115237 | Nivel 4 | AF 21
1115243 | Nivel 4 | AF 21
1115249 | Nivel 4 | AF 21
1115261 | Nivel 4 | AF 21
1115267 | Nivel 4 | AF 21
1115281 | Nivel 4 | AF 21
1115362 | Nivel 4 | AF 37
1115372 | Nivel 4 | AF 37
1115378 | Nivel 4 | AF 37
1115386 | Nivel 4 | AF 37
1115392 | Nivel 4 | AF 37
1115400 | Nivel 4 | AF 37
1115406 | Nivel 4 | AF 37
1115412 | Nivel 4 | AF 37
1115418 | Nivel 4 | AF 37
