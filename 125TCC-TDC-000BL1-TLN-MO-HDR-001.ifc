Properties of the parts of a building model (IFC4), part 16 of 21

# IfcPipeFitting: D2010 - Tapon PVC.P:Standard (288)
Name (D2010 - Tapon PVC.P:Standard:...) | In | Group
1115430 | Nivel 4 | AF 37
1115436 | Nivel 4 | AF 37
1115450 | Nivel 4 | AF 37
1115519 | Nivel 4 | AF 53
1115529 | Nivel 4 | AF 53
1115535 | Nivel 4 | AF 53
1115543 | Nivel 4 | AF 53
1115549 | Nivel 4 | AF 53
1115557 | Nivel 4 | AF 53
1115563 | Nivel 4 | AF 53
1115569 | Nivel 4 | AF 53
1115575 | Nivel 4 | AF 53
1115587 | Nivel 4 | AF 53
1115593 | Nivel 4 | AF 53
1115607 | Nivel 4 | AF 53
1116091 | Nivel 5 | AF 6
1116101 | Nivel 5 | AF 6
1116107 | Nivel 5 | AF 6
1116115 | Nivel 5 | AF 6
1116121 | Nivel 5 | AF 6
1116129 | Nivel 5 | AF 6
1116135 | Nivel 5 | AF 6
1116141 | Nivel 5 | AF 6
1116147 | Nivel 5 | AF 6
1116159 | Nivel 5 | AF 6
1116165 | Nivel 5 | AF 6
1116179 | Nivel 5 | AF 6
1116246 | Nivel 5 | AF 23
1116256 | Nivel 5 | AF 23
1116262 | Nivel 5 | AF 23
1116270 | Nivel 5 | AF 23
1116276 | Nivel 5 | AF 23
1116284 | Nivel 5 | AF 23
1116290 | Nivel 5 | AF 23
1116296 | Nivel 5 | AF 23
1116302 | Nivel 5 | AF 23
1116314 | Nivel 5 | AF 23
1116320 | Nivel 5 | AF 23
1116334 | Nivel 5 | AF 23
1116415 | Nivel 5 | AF 40
1116425 | Nivel 5 | AF 40
1116431 | Nivel 5 | AF 40
1116439 | Nivel 5 | AF 40
1116445 | Nivel 5 | AF 40
1116453 | Nivel 5 | AF 40
1116459 | Nivel 5 | AF 40
1116465 | Nivel 5 | AF 40
1116471 | Nivel 5 | AF 40
1116483 | Nivel 5 | AF 40
1116489 | Nivel 5 | AF 40
1116503 | Nivel 5 | AF 40
1116572 | Nivel 5 | AF 57
1116582 | Nivel 5 | AF 57
1116588 | Nivel 5 | AF 57
1116596 | Nivel 5 | AF 57
1116602 | Nivel 5 | AF 57
1116610 | Nivel 5 | AF 57
1116616 | Nivel 5 | AF 57
1116622 | Nivel 5 | AF 57
1116628 | Nivel 5 | AF 57
1116640 | Nivel 5 | AF 57
1116646 | Nivel 5 | AF 57
1116660 | Nivel 5 | AF 57
1117132 | Nivel 6 | AF 7
1117142 | Nivel 6 | AF 7
1117148 | Nivel 6 | AF 7
1117156 | Nivel 6 | AF 7
1117162 | Nivel 6 | AF 7
1117170 | Nivel 6 | AF 7
1117176 | Nivel 6 | AF 7
1117182 | Nivel 6 | AF 7
1117188 | Nivel 6 | AF 7
1117200 | Nivel 6 | AF 7
1117206 | Nivel 6 | AF 7
1117220 | Nivel 6 | AF 7
1117287 | Nivel 6 | AC 16
1117297 | Nivel 6 | AC 16
1117303 | Nivel 6 | AC 16
1117311 | Nivel 6 | AC 16
1117317 | Nivel 6 | AC 16
1117325 | Nivel 6 | AC 16
1117331 | Nivel 6 | AC 16
1117337 | Nivel 6 | AC 16
1117343 | Nivel 6 | AC 16
1117355 | Nivel 6 | AC 16
1117361 | Nivel 6 | AC 16
1117375 | Nivel 6 | AC 16
1117456 | Nivel 6 | AF 43
1117466 | Nivel 6 | AF 43
1117472 | Nivel 6 | AF 43
1117480 | Nivel 6 | AF 43
1117486 | Nivel 6 | AF 43
1117494 | Nivel 6 | AF 43
1117500 | Nivel 6 | AF 43
1117506 | Nivel 6 | AF 43
1117512 | Nivel 6 | AF 43
1117524 | Nivel 6 | AF 43
1117530 | Nivel 6 | AF 43
1117544 | Nivel 6 | AF 43
1117613 | Nivel 6 | AF 61
1117623 | Nivel 6 | AF 61
1117629 | Nivel 6 | AF 61
1117637 | Nivel 6 | AF 61
1117643 | Nivel 6 | AF 61
1117651 | Nivel 6 | AF 61
1117657 | Nivel 6 | AF 61
1117663 | Nivel 6 | AF 61
1117669 | Nivel 6 | AF 61
1117681 | Nivel 6 | AF 61
1117687 | Nivel 6 | AF 61
1117701 | Nivel 6 | AF 61
1243830 | Nivel 1 | AF 3

# IfcPipeFitting: D2010 - Tee CPVC.P:Standard (24)
Type - Material: CPVC
Classification: 21.04.20.10.40 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2010 - Tee CPVC.P:Standard:...) | In | Group
963302 | Nivel 2 | AC 1
1063924 | Nivel 2 | AC 2
1065554 | Nivel 2 | AC 4
1066509 | Nivel 2 | AC 5
1106445 | Nivel 1 | AC 3
1106498 | Nivel 1 | AC 8
1106543 | Nivel 1 | AC 11
1106612 | Nivel 1 | AC 14
1113722 | Nivel 3 | AC 6
1113775 | Nivel 3 | AC 10
1113820 | Nivel 3 | AC 15
1113889 | Nivel 3 | AC 18
1114775 | Nivel 4 | AC 7
1114828 | Nivel 4 | AC 13
1114873 | Nivel 4 | AC 19
1114942 | Nivel 4 | AC 22
1115828 | Nivel 5 | AC 9
1115881 | Nivel 5 | AC 17
1115926 | Nivel 5 | AC 23
1115995 | Nivel 5 | AC 26
1116869 | Nivel 6 | AC 12
1116922 | Nivel 6 | AC 21
1116967 | Nivel 6 | AC 27
1117036 | Nivel 6 | AC 30

# IfcPipeFitting: D2010 - Tee PVC.P:Standard (294)
Type - Material: PVC agua fria
Classification: 21.04.20.10.40 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2010 - Tee PVC.P:Standard:...) | In | Group
1061065 | Nivel 1 | AF 2
1061211 | Nivel 6 | AF 2
1061261 | Nivel 5 | AF 2
1061284 | Nivel 4 | AF 2
1061342 | Nivel 3 | AF 2
1061386 | Nivel 2 | AF 2
1110024 | Nivel 2 | AF 1
1110032 | Nivel 2 | AF 1
1110036 | Nivel 2 | AF 1
1110046 | Nivel 2 | AF 1
1110056 | Nivel 2 | AF 1
1110060 | Nivel 2 | AF 1
1110088 | Nivel 2 | AF 1
1110102 | Nivel 2 | AF 1
1110116 | Nivel 2 | AF 1
1110128 | Nivel 2 | AF 1
1110146 | Nivel 2 | AF 1
1110160 | Nivel 2 | AF 1
1110183 | Nivel 2 | AF 16
1110191 | Nivel 2 | AF 16
1110195 | Nivel 2 | AF 16
1110211 | Nivel 2 | AF 16
1110215 | Nivel 2 | AF 16
1110243 | Nivel 2 | AF 16
1110257 | Nivel 2 | AF 16
1110271 | Nivel 2 | AF 16
1110283 | Nivel 2 | AF 16
1110301 | Nivel 2 | AF 16
1110315 | Nivel 2 | AF 16
1110332 | Nivel 2 | AF 16
1110348 | Nivel 2 | AF 30
1110356 | Nivel 2 | AF 30
1110360 | Nivel 2 | AF 30
1110370 | Nivel 2 | AF 30
1110380 | Nivel 2 | AF 30
1110384 | Nivel 2 | AF 30
1110412 | Nivel 2 | AF 30
1110426 | Nivel 2 | AF 30
1110440 | Nivel 2 | AF 30
1110452 | Nivel 2 | AF 30
1110470 | Nivel 2 | AF 30
1110484 | Nivel 2 | AF 30
1110509 | Nivel 2 | AF 44
1110517 | Nivel 2 | AF 44
1110521 | Nivel 2 | AF 44
1110537 | Nivel 2 | AF 44
1110541 | Nivel 2 | AF 44
1110569 | Nivel 2 | AF 44
1110583 | Nivel 2 | AF 44
1110597 | Nivel 2 | AF 44
1110609 | Nivel 2 | AF 44
1110627 | Nivel 2 | AF 44
1110641 | Nivel 2 | AF 44
1110656 | Nivel 2 | AF 44
1112758 | Nivel 1 | AF 3
1112766 | Nivel 1 | AF 3
1112770 | Nivel 1 | AF 3
1112780 | Nivel 1 | AF 3
1112790 | Nivel 1 | AF 3
1112794 | Nivel 1 | AF 3
1112822 | Nivel 1 | AF 3
1112836 | Nivel 1 | AF 3
1112850 | Nivel 1 | AF 3
1112862 | Nivel 1 | AF 3
1112880 | Nivel 1 | AF 3
1112894 | Nivel 1 | AF 3
1112917 | Nivel 1 | AF 17
1112925 | Nivel 1 | AF 17
1112929 | Nivel 1 | AF 17
1112945 | Nivel 1 | AF 17
1112949 | Nivel 1 | AF 17
1112977 | Nivel 1 | AF 17
1112991 | Nivel 1 | AF 17
1113005 | Nivel 1 | AF 17
1113017 | Nivel 1 | AF 17
1113035 | Nivel 1 | AF 17
1113049 | Nivel 1 | AF 17
1113066 | Nivel 1 | AF 17
1113082 | Nivel 1 | AF 31
1113090 | Nivel 1 | AF 31
1113094 | Nivel 1 | AF 31
1113104 | Nivel 1 | AF 31
1113114 | Nivel 1 | AF 31
1113118 | Nivel 1 | AF 31
1113146 | Nivel 1 | AF 31
1113160 | Nivel 1 | AF 31
1113174 | Nivel 1 | AF 31
1113186 | Nivel 1 | AF 31
1113204 | Nivel 1 | AF 31
1113218 | Nivel 1 | AF 31
1113243 | Nivel 1 | AF 45
1113251 | Nivel 1 | AF 45
1113255 | Nivel 1 | AF 45
1113271 | Nivel 1 | AF 45
1113275 | Nivel 1 | AF 45
1113303 | Nivel 1 | AF 45
1113317 | Nivel 1 | AF 45
1113331 | Nivel 1 | AF 45
1113343 | Nivel 1 | AF 45
1113361 | Nivel 1 | AF 45
1113375 | Nivel 1 | AF 45
1113390 | Nivel 1 | AF 45
1113933 | Nivel 3 | AF 4
1113941 | Nivel 3 | AF 4
1113945 | Nivel 3 | AF 4
1113955 | Nivel 3 | AF 4
1113965 | Nivel 3 | AF 4
1113969 | Nivel 3 | AF 4
1113997 | Nivel 3 | AF 4
1114011 | Nivel 3 | AF 4
1114025 | Nivel 3 | AF 4
1114037 | Nivel 3 | AF 4
1114055 | Nivel 3 | AF 4
1114069 | Nivel 3 | AF 4
1114092 | Nivel 3 | AF 19
1114100 | Nivel 3 | AF 19
1114104 | Nivel 3 | AF 19
1114120 | Nivel 3 | AF 19
1114124 | Nivel 3 | AF 19
1114152 | Nivel 3 | AF 19
1114166 | Nivel 3 | AF 19
1114180 | Nivel 3 | AF 19
1114192 | Nivel 3 | AF 19
1114210 | Nivel 3 | AF 19
1114224 | Nivel 3 | AF 19
1114241 | Nivel 3 | AF 19
1114257 | Nivel 3 | AF 34
1114265 | Nivel 3 | AF 34
1114269 | Nivel 3 | AF 34
1114279 | Nivel 3 | AF 34
1114289 | Nivel 3 | AF 34
1114293 | Nivel 3 | AF 34
1114321 | Nivel 3 | AF 34
1114335 | Nivel 3 | AF 34
1114349 | Nivel 3 | AF 34
1114361 | Nivel 3 | AF 34
1114379 | Nivel 3 | AF 34
1114393 | Nivel 3 | AF 34
1114418 | Nivel 3 | AF 49
1114426 | Nivel 3 | AF 49
1114430 | Nivel 3 | AF 49
1114446 | Nivel 3 | AF 49
1114450 | Nivel 3 | AF 49
1114478 | Nivel 3 | AF 49
1114492 | Nivel 3 | AF 49
1114506 | Nivel 3 | AF 49
1114518 | Nivel 3 | AF 49
1114536 | Nivel 3 | AF 49
1114550 | Nivel 3 | AF 49
1114565 | Nivel 3 | AF 49
1114986 | Nivel 4 | AF 5
1114994 | Nivel 4 | AF 5
1114998 | Nivel 4 | AF 5
1115008 | Nivel 4 | AF 5
1115018 | Nivel 4 | AF 5
1115022 | Nivel 4 | AF 5
1115050 | Nivel 4 | AF 5
1115064 | Nivel 4 | AF 5
1115078 | Nivel 4 | AF 5
1115090 | Nivel 4 | AF 5
1115108 | Nivel 4 | AF 5
1115122 | Nivel 4 | AF 5
1115145 | Nivel 4 | AF 21
1115153 | Nivel 4 | AF 21
1115157 | Nivel 4 | AF 21
1115173 | Nivel 4 | AF 21
1115177 | Nivel 4 | AF 21
1115205 | Nivel 4 | AF 21
1115219 | Nivel 4 | AF 21
1115233 | Nivel 4 | AF 21
1115245 | Nivel 4 | AF 21
1115263 | Nivel 4 | AF 21
1115277 | Nivel 4 | AF 21
1115294 | Nivel 4 | AF 21
1115310 | Nivel 4 | AF 37
1115318 | Nivel 4 | AF 37
1115322 | Nivel 4 | AF 37
1115332 | Nivel 4 | AF 37
1115342 | Nivel 4 | AF 37
1115346 | Nivel 4 | AF 37
1115374 | Nivel 4 | AF 37
1115388 | Nivel 4 | AF 37
1115402 | Nivel 4 | AF 37
1115414 | Nivel 4 | AF 37
1115432 | Nivel 4 | AF 37
1115446 | Nivel 4 | AF 37
1115471 | Nivel 4 | AF 53
1115479 | Nivel 4 | AF 53
1115483 | Nivel 4 | AF 53
1115499 | Nivel 4 | AF 53
1115503 | Nivel 4 | AF 53
1115531 | Nivel 4 | AF 53
1115545 | Nivel 4 | AF 53
1115559 | Nivel 4 | AF 53
1115571 | Nivel 4 | AF 53
1115589 | Nivel 4 | AF 53
1115603 | Nivel 4 | AF 53
1115618 | Nivel 4 | AF 53
1116039 | Nivel 5 | AF 6
1116047 | Nivel 5 | AF 6
1116051 | Nivel 5 | AF 6
1116061 | Nivel 5 | AF 6
1116071 | Nivel 5 | AF 6
1116075 | Nivel 5 | AF 6
1116103 | Nivel 5 | AF 6
1116117 | Nivel 5 | AF 6
1116131 | Nivel 5 | AF 6
1116143 | Nivel 5 | AF 6
1116161 | Nivel 5 | AF 6
1116175 | Nivel 5 | AF 6
1116198 | Nivel 5 | AF 23
1116206 | Nivel 5 | AF 23
1116210 | Nivel 5 | AF 23
1116226 | Nivel 5 | AF 23
1116230 | Nivel 5 | AF 23
1116258 | Nivel 5 | AF 23
1116272 | Nivel 5 | AF 23
1116286 | Nivel 5 | AF 23
1116298 | Nivel 5 | AF 23
1116316 | Nivel 5 | AF 23
1116330 | Nivel 5 | AF 23
1116347 | Nivel 5 | AF 23
1116363 | Nivel 5 | AF 40
1116371 | Nivel 5 | AF 40
1116375 | Nivel 5 | AF 40
1116385 | Nivel 5 | AF 40
1116395 | Nivel 5 | AF 40
1116399 | Nivel 5 | AF 40
1116427 | Nivel 5 | AF 40
1116441 | Nivel 5 | AF 40
1116455 | Nivel 5 | AF 40
1116467 | Nivel 5 | AF 40
1116485 | Nivel 5 | AF 40
1116499 | Nivel 5 | AF 40
1116524 | Nivel 5 | AF 57
1116532 | Nivel 5 | AF 57
1116536 | Nivel 5 | AF 57
1116552 | Nivel 5 | AF 57
1116556 | Nivel 5 | AF 57
1116584 | Nivel 5 | AF 57
1116598 | Nivel 5 | AF 57
1116612 | Nivel 5 | AF 57
1116624 | Nivel 5 | AF 57
1116642 | Nivel 5 | AF 57
1116656 | Nivel 5 | AF 57
1116671 | Nivel 5 | AF 57
1117080 | Nivel 6 | AF 7
1117088 | Nivel 6 | AF 7
1117092 | Nivel 6 | AF 7
1117102 | Nivel 6 | AF 7
1117112 | Nivel 6 | AF 7
1117116 | Nivel 6 | AF 7
1117144 | Nivel 6 | AF 7
1117158 | Nivel 6 | AF 7
1117172 | Nivel 6 | AF 7
1117184 | Nivel 6 | AF 7
1117202 | Nivel 6 | AF 7
1117216 | Nivel 6 | AF 7
1117239 | Nivel 6 | AC 16
1117247 | Nivel 6 | AC 16
1117251 | Nivel 6 | AC 16
1117267 | Nivel 6 | AC 16
1117271 | Nivel 6 | AC 16
1117299 | Nivel 6 | AC 16
1117313 | Nivel 6 | AC 16
1117327 | Nivel 6 | AC 16
1117339 | Nivel 6 | AC 16
1117357 | Nivel 6 | AC 16
1117371 | Nivel 6 | AC 16
1117388 | Nivel 6 | AC 16
1117404 | Nivel 6 | AF 43
1117412 | Nivel 6 | AF 43
1117416 | Nivel 6 | AF 43
1117426 | Nivel 6 | AF 43
1117436 | Nivel 6 | AF 43
1117440 | Nivel 6 | AF 43
1117468 | Nivel 6 | AF 43
1117482 | Nivel 6 | AF 43
1117496 | Nivel 6 | AF 43
1117508 | Nivel 6 | AF 43
1117526 | Nivel 6 | AF 43
1117540 | Nivel 6 | AF 43
1117565 | Nivel 6 | AF 61
1117573 | Nivel 6 | AF 61
1117577 | Nivel 6 | AF 61
1117593 | Nivel 6 | AF 61
1117597 | Nivel 6 | AF 61
1117625 | Nivel 6 | AF 61
1117639 | Nivel 6 | AF 61
1117653 | Nivel 6 | AF 61
1117665 | Nivel 6 | AF 61
1117683 | Nivel 6 | AF 61
1117697 | Nivel 6 | AF 61
1117712 | Nivel 6 | AF 61

# IfcPipeFitting: D2020 - Buje Soldado PVC.LL:Standard, D2020 - Buje Soldado PVC.LL:Standard:1246052
In: Nivel 1
Type - PredefinedType: BEND; Material: PVC
Type - Pset_ManufacturerTypeInformation - Manufacturer: PAVCO - PAVCO (c) 9/27/2017 6:10:36 PM -05:00
Classification: 21.04.20.30.20 Uniformat (Uniformat); Group: ALL 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Qto_PipeFittingBaseQuantities - Length: 0.012318 m; GrossCrossSectionArea: 0.00910884 m2; NetCrossSectionArea: 0.00910884 m2; OuterSurfaceArea: 0.012073 m2

# IfcPipeFitting: D2020 - Buje Soldado PVC.S:Standard (4)
Type - PredefinedType: BEND; Material: PVC
Type - Pset_ManufacturerTypeInformation - Manufacturer: PAVCO - PAVCO (c) 9/27/2017 6:10:36 PM -05:00
Classification: 21.04.20.20.30 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2020 - Buje Soldado PVC.S:Standard:...) | In | Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Group
1068652 | Nivel 1 | 0.006602 | 0.00233166 | 0.00549505 | AR-DOM 4
1075123 | Nivel 1 | 0.006602 | 0.00233166 | 0.00549505 | AR-DOM 4
1379878 | Nivel 1 | 0.008891 | 0.00455856 | 0.00816426 | ALL 1
1486510 | Nivel 6 | 0.006602 | 0.00342281 | 0.00136931 | VENT 3

# IfcPipeFitting: D2020 - Codo CxC PVC.LL:Standard (32)
In: Nivel 1
Type - PredefinedType: BEND; Material: PVC
Classification: 21.04.20.30.20 Uniformat (Uniformat); Group: ALL 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2020 - Codo CxC PVC.LL:Standard:...)
1084324
1084335
1085118
1085195
1085312
1085454
1086143
1086147
1086155
1086159
1086181
1086183
1086189
1086201
1086205
1089581
1089693
1090144
1090160
1090223
1090225
1200073
1200272
1200687
1220303
1220331
1246301
1331665
1378550
1379323
1379874
1486792

# IfcPipeFitting: D2020 - Codo CxC PVC.S:Standard (583)
Type - Material: PVC
Classification: 21.04.20.20.30 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2020 - Codo CxC PVC.S:Standard:...) | In | Group
948071 | Nivel 1 | AR-DOM 1
948082 | Nivel 1 | AR-DOM 1
948217 | Nivel 1 | AR-DOM 1
948227 | Nivel 2 | AR-DOM 1
948454 | Nivel 2 | AR-DOM 1
948464 | Nivel 2 | AR-DOM 1
948498 | Nivel 2 | AR-DOM 1
948508 | Nivel 2 | AR-DOM 1
949076 | Nivel 2 | AR-DOM 1
949521 | Nivel 2 | AR-DOM 1
950588 | Nivel 2 | AR-DOM 1
950860 | Nivel 2 | AR-DOM 1
952230 | Nivel 2 | AR-DOM 1
954344 | Nivel 2 | AR-DOM 1
954362 | Nivel 2 | AR-DOM 1
955929 | Nivel 2 | AR-DOM 1
955933 | Nivel 2 | AR-DOM 1
956218 | Nivel 2 | AR-DOM 1
956430 | Nivel 1 | AR-DOM 1
956438 | Nivel 1 | AR-DOM 1
957140 | Nivel 2 | AR-DOM 1
957172 | Nivel 2 | AR-DOM 1
1067379 | Nivel 1 | AR-DOM 4
1068214 | Nivel 1 | AR-DOM 4
1068547 | Nivel 1 | AR-DOM 4
1068664 | Nivel 1 | AR-DOM 4
1068675 | Nivel 1 | AR-DOM 4
1069704 | Nivel 1 | AR-DOM 4
1069715 | Nivel 1 | AR-DOM 4
1069766 | Nivel 1 | AR-DOM 4
1069774 | Nivel 1 | AR-DOM 4
1069784 | Nivel 1 | AR-DOM 4
1070155 | Nivel 1 | AR-DOM 4
1070303 | Nivel 1 | AR-DOM 4
1070317 | Nivel 1 | AR-DOM 4
1070329 | Nivel 1 | AR-DOM 4
1070639 | Nivel 1 | AR-DOM 4
1070929 | Nivel 1 | AR-DOM 4
1070939 | Nivel 1 | AR-DOM 4
1071235 | Nivel 1 | AR-DOM 4
1071585 | Nivel 1 | AR-DOM 4
1071606 | Nivel 1 | AR-DOM 4
1071868 | Nivel 1 | AR-DOM 4
1071876 | Nivel 1 | AR-DOM 4
1071886 | Nivel 1 | AR-DOM 4
1072146 | Nivel 1 | AR-DOM 4
1072330 | Nivel 1 | AR-DOM 4
1072441 | Nivel 1 | AR-DOM 4
1072540 | Nivel 1 | AR-DOM 4
1072808 | Nivel 1 | AR-DOM 4
1072819 | Nivel 1 | AR-DOM 4
1072950 | Nivel 1 | AR-DOM 4
1072960 | Nivel 1 | AR-DOM 4
1073124 | Nivel 1 | AR-DOM 4
1073840 | Nivel 1 | AR-DOM 4
1074288 | Nivel 1 | AR-DOM 4
1074348 | Nivel 1 | AR-DOM 4
1074358 | Nivel 1 | AR-DOM 4
1074415 | Nivel 1 | AR-DOM 4
1074442 | Nivel 1 | AR-DOM 4
1074454 | Nivel 1 | AR-DOM 4
1074864 | Nivel 1 | AR-DOM 4
1074942 | Nivel 1 | AR-DOM 4
1075097 | Nivel 1 | AR-DOM 4
1075107 | Nivel 1 | AR-DOM 4
1075117 | Nivel 1 | AR-DOM 4
1075127 | Nivel 1 | AR-DOM 4
1075131 | Nivel 1 | AR-DOM 4
1075163 | Nivel 1 | AR-DOM 4
1075165 | Nivel 1 | AR-DOM 4
1075169 | Nivel 1 | AR-DOM 4
1075173 | Nivel 1 | AR-DOM 4
1075175 | Nivel 1 | AR-DOM 4
1075181 | Nivel 1 | AR-DOM 4
1075187 | Nivel 1 | AR-DOM 4
1075191 | Nivel 1 | AR-DOM 4
1075195 | Nivel 1 | AR-DOM 4
1075199 | Nivel 1 | AR-DOM 4
1075209 | Nivel 1 | AR-DOM 4
1075213 | Nivel 1 | AR-DOM 4
1075229 | Nivel 1 | AR-DOM 4
1075235 | Nivel 1 | AR-DOM 4
1075239 | Nivel 1 | AR-DOM 4
1075243 | Nivel 1 | AR-DOM 4
1075247 | Nivel 1 | AR-DOM 4
1075255 | Nivel 1 | AR-DOM 4
1075267 | Nivel 1 | AR-DOM 4
1075273 | Nivel 1 | AR-DOM 4
1075289 | Nivel 1 | AR-DOM 4
1075293 | Nivel 1 | AR-DOM 4
1075301 | Nivel 1 | AR-DOM 4
1075305 | Nivel 1 | AR-DOM 4
1075313 | Nivel 1 | AR-DOM 4
1075319 | Nivel 1 | AR-DOM 4
1075333 | Nivel 1 | AR-DOM 4
1075337 | Nivel 1 | AR-DOM 4
1075339 | Nivel 1 | AR-DOM 4
1075343 | Nivel 1 | AR-DOM 4
1075347 | Nivel 1 | AR-DOM 4
1075351 | Nivel 1 | AR-DOM 4
1075464 | Nivel 1 | AR-DOM 4
1075669 | Nivel 1 | AR-DOM 4
1075784 | Nivel 1 | AR-DOM 4
1075841 | Nivel 1 | AR-DOM 4
1075887 | Nivel 1 | AR-DOM 4
1075901 | Nivel 1 | AR-DOM 4
1076196 | Nivel 1 | AR-DOM 4
1076761 | Nivel 2 | AR-DOM 1
1077019 | Nivel 2 | AR-DOM 1
1077124 | Nivel 1 | AR-DOM 1
1078345 | Nivel 1 | AR-DOM 1
1078545 | Nivel 1 | AR-DOM 1
1078642 | Nivel 1 | AR-DOM 1
1078767 | Nivel 1 | AR-DOM 1
1081098 | Nivel 1 | AR-DOM 4; VENT 3
1081594 | Nivel 1 | AR-DOM 4; VENT 6
1081635 | Nivel 1 | VENT 6
1081646 | Nivel 1 | VENT 6
1082067 | Nivel 1 | VENT 2; AR-DOM 4
1082094 | Nivel 1 | VENT 2
1082166 | Nivel 1 | VENT 2
1082802 | Nivel 1 | VENT 1; AR-DOM 4
1088118 | Nivel 1 | AR-DOM 4
1091360 | Nivel 1 | VENT 1
1091975 | Nivel 2 | AR-DOM 1
1091979 | Nivel 2 | AR-DOM 1
1091983 | Nivel 2 | AR-DOM 1
1091987 | Nivel 3 | AR-DOM 1
1091993 | Nivel 3 | AR-DOM 1
1091995 | Nivel 3 | AR-DOM 1
1091999 | Nivel 3 | AR-DOM 1
1092001 | Nivel 3 | AR-DOM 1
1092023 | Nivel 3 | AR-DOM 1
1092033 | Nivel 3 | AR-DOM 1
1092037 | Nivel 3 | AR-DOM 1
1092045 | Nivel 3 | AR-DOM 1
1092051 | Nivel 3 | AR-DOM 1
1092085 | Nivel 3 | AR-DOM 1
1092091 | Nivel 3 | AR-DOM 1
1092103 | Nivel 3 | AR-DOM 1
1092105 | Nivel 3 | AR-DOM 1
1092109 | Nivel 3 | AR-DOM 1
1092115 | Nivel 2 | AR-DOM 1
1092119 | Nivel 2 | AR-DOM 1
1092125 | Nivel 3 | AR-DOM 1
1092129 | Nivel 3 | AR-DOM 1
1092384 | Nivel 3 | AR-DOM 1
1092388 | Nivel 3 | AR-DOM 1
1092392 | Nivel 3 | AR-DOM 1
1092396 | Nivel 4 | AR-DOM 1
1092402 | Nivel 4 | AR-DOM 1
1092404 | Nivel 4 | AR-DOM 1
1092408 | Nivel 4 | AR-DOM 1
1092410 | Nivel 4 | AR-DOM 1
1092432 | Nivel 4 | AR-DOM 1
1092442 | Nivel 4 | AR-DOM 1
1092446 | Nivel 4 | AR-DOM 1
1092454 | Nivel 4 | AR-DOM 1
1092460 | Nivel 4 | AR-DOM 1
1092494 | Nivel 4 | AR-DOM 1
1092500 | Nivel 4 | AR-DOM 1
1092512 | Nivel 4 | AR-DOM 1
1092514 | Nivel 4 | AR-DOM 1
1092518 | Nivel 4 | AR-DOM 1
1092524 | Nivel 3 | AR-DOM 1
1092528 | Nivel 3 | AR-DOM 1
1092534 | Nivel 4 | AR-DOM 1
1092538 | Nivel 4 | AR-DOM 1
1092792 | Nivel 4 | AR-DOM 1
1092796 | Nivel 4 | AR-DOM 1
1092800 | Nivel 4 | AR-DOM 1
1092804 | Nivel 5 | AR-DOM 1
1092810 | Nivel 5 | AR-DOM 1
1092812 | Nivel 5 | AR-DOM 1
1092816 | Nivel 5 | AR-DOM 1
1092818 | Nivel 5 | AR-DOM 1
1092840 | Nivel 5 | AR-DOM 1
1092850 | Nivel 5 | AR-DOM 1
1092854 | Nivel 5 | AR-DOM 1
1092862 | Nivel 5 | AR-DOM 1
1092868 | Nivel 5 | AR-DOM 1
1092902 | Nivel 5 | AR-DOM 1
1092908 | Nivel 5 | AR-DOM 1
1092920 | Nivel 5 | AR-DOM 1
1092922 | Nivel 5 | AR-DOM 1
1092926 | Nivel 5 | AR-DOM 1
1092932 | Nivel 4 | AR-DOM 1
1092936 | Nivel 4 | AR-DOM 1
1092942 | Nivel 5 | AR-DOM 1
1092946 | Nivel 5 | AR-DOM 1
1093200 | Nivel 5 | AR-DOM 1
1093204 | Nivel 5 | AR-DOM 1
1093208 | Nivel 5 | AR-DOM 1
1093212 | Nivel 6 | AR-DOM 1
1093218 | Nivel 6 | AR-DOM 1
1093220 | Nivel 6 | AR-DOM 1
1093224 | Nivel 6 | AR-DOM 1
1093226 | Nivel 6 | AR-DOM 1
1093248 | Nivel 6 | AR-DOM 1
1093258 | Nivel 6 | AR-DOM 1
1093262 | Nivel 6 | AR-DOM 1
1093270 | Nivel 6 | AR-DOM 1
1093276 | Nivel 6 | AR-DOM 1
1093310 | Nivel 6 | AR-DOM 1
1093316 | Nivel 6 | AR-DOM 1
1093328 | Nivel 6 | AR-DOM 1
1093330 | Nivel 6 | AR-DOM 1
1093334 | Nivel 6 | AR-DOM 1
1093340 | Nivel 5 | AR-DOM 1
1093344 | Nivel 5 | AR-DOM 1
1093350 | Nivel 6 | AR-DOM 1
1093354 | Nivel 6 | AR-DOM 1
1093872 | Nivel 6 | VENT 1
1093984 | Nivel 6 | VENT 1
1093997 | Nivel 6 | VENT 1
1095254 | Nivel 1 | AR-DOM 1
1095258 | Nivel 1 | AR-DOM 1
1095262 | Nivel 1 | AR-DOM 1
1095266 | Nivel 2 | AR-DOM 1
1095272 | Nivel 2 | AR-DOM 1
1095274 | Nivel 2 | AR-DOM 1
1095278 | Nivel 2 | AR-DOM 1
1095280 | Nivel 2 | AR-DOM 1
1095302 | Nivel 2 | AR-DOM 1
1095312 | Nivel 2 | AR-DOM 1
1095316 | Nivel 2 | AR-DOM 1
1095324 | Nivel 2 | AR-DOM 1
1095330 | Nivel 2 | AR-DOM 1
1095364 | Nivel 2 | AR-DOM 1
1095370 | Nivel 2 | AR-DOM 1
1095382 | Nivel 2 | AR-DOM 1
1095384 | Nivel 2 | AR-DOM 1
1095388 | Nivel 2 | AR-DOM 1
1095394 | Nivel 1 | AR-DOM 1
1095398 | Nivel 1 | AR-DOM 1
1095404 | Nivel 2 | AR-DOM 1
1095408 | Nivel 2 | AR-DOM 1
1095428 | Nivel 2 | AR-DOM 1
1095432 | Nivel 2 | AR-DOM 1
1095436 | Nivel 2 | AR-DOM 1
1095440 | Nivel 3 | AR-DOM 1
1095446 | Nivel 3 | AR-DOM 1
1095448 | Nivel 3 | AR-DOM 1
1095452 | Nivel 3 | AR-DOM 1
1095454 | Nivel 3 | AR-DOM 1
1095476 | Nivel 3 | AR-DOM 1
1095486 | Nivel 3 | AR-DOM 1
1095490 | Nivel 3 | AR-DOM 1
1095498 | Nivel 3 | AR-DOM 1
1095504 | Nivel 3 | AR-DOM 1
1095538 | Nivel 3 | AR-DOM 1
1095544 | Nivel 3 | AR-DOM 1
1095556 | Nivel 3 | AR-DOM 1
1095558 | Nivel 3 | AR-DOM 1
1095562 | Nivel 3 | AR-DOM 1
1095568 | Nivel 2 | AR-DOM 1
1095572 | Nivel 2 | AR-DOM 1
1095578 | Nivel 3 | AR-DOM 1
1095582 | Nivel 3 | AR-DOM 1
1095598 | Nivel 3 | AR-DOM 1
1095602 | Nivel 3 | AR-DOM 1
1095606 | Nivel 3 | AR-DOM 1
1095610 | Nivel 4 | AR-DOM 1
1095616 | Nivel 4 | AR-DOM 1
1095618 | Nivel 4 | AR-DOM 1
1095622 | Nivel 4 | AR-DOM 1
1095624 | Nivel 4 | AR-DOM 1
1095646 | Nivel 4 | AR-DOM 1
1095654 | Nivel 4 | AR-DOM 1
1095658 | Nivel 4 | AR-DOM 1
1095666 | Nivel 4 | AR-DOM 1
1095672 | Nivel 4 | AR-DOM 1
1095706 | Nivel 4 | AR-DOM 1
1095712 | Nivel 4 | AR-DOM 1
1095724 | Nivel 4 | AR-DOM 1
1095726 | Nivel 4 | AR-DOM 1
1095730 | Nivel 4 | AR-DOM 1
1095736 | Nivel 3 | AR-DOM 1
1095740 | Nivel 3 | AR-DOM 1
1095746 | Nivel 4 | AR-DOM 1
1095750 | Nivel 4 | AR-DOM 1
1095766 | Nivel 4 | AR-DOM 1
1095770 | Nivel 4 | AR-DOM 1
1095774 | Nivel 4 | AR-DOM 1
1095778 | Nivel 5 | AR-DOM 1
1095784 | Nivel 5 | AR-DOM 1
1095786 | Nivel 5 | AR-DOM 1
1095790 | Nivel 5 | AR-DOM 1
1095792 | Nivel 5 | AR-DOM 1
1095814 | Nivel 5 | AR-DOM 1
1095824 | Nivel 5 | AR-DOM 1
1095828 | Nivel 5 | AR-DOM 1
1095836 | Nivel 5 | AR-DOM 1
1095842 | Nivel 5 | AR-DOM 1
1095876 | Nivel 5 | AR-DOM 1
1095882 | Nivel 5 | AR-DOM 1
1095894 | Nivel 5 | AR-DOM 1
1095896 | Nivel 5 | AR-DOM 1
1095900 | Nivel 5 | AR-DOM 1
1095906 | Nivel 4 | AR-DOM 1
1095910 | Nivel 4 | AR-DOM 1
1095916 | Nivel 5 | AR-DOM 1
1095920 | Nivel 5 | AR-DOM 1
1095938 | Nivel 5 | AR-DOM 1
1095942 | Nivel 5 | AR-DOM 1
1095946 | Nivel 5 | AR-DOM 1
1095950 | Nivel 6 | AR-DOM 1
1095956 | Nivel 6 | AR-DOM 1
1095958 | Nivel 6 | AR-DOM 1
1095962 | Nivel 6 | AR-DOM 1
1095964 | Nivel 6 | AR-DOM 1
1095986 | Nivel 6 | AR-DOM 1
1095994 | Nivel 6 | AR-DOM 1
1095998 | Nivel 6 | AR-DOM 1
1096006 | Nivel 6 | AR-DOM 1
1096012 | Nivel 6 | AR-DOM 1
1096044 | Nivel 6 | AR-DOM 1
1096050 | Nivel 6 | AR-DOM 1
1096062 | Nivel 6 | AR-DOM 1
1096064 | Nivel 6 | AR-DOM 1
1096068 | Nivel 6 | AR-DOM 1
1096074 | Nivel 5 | AR-DOM 1
1096078 | Nivel 5 | AR-DOM 1
1096084 | Nivel 6 | AR-DOM 1
1096088 | Nivel 6 | AR-DOM 1
1096106 | Nivel 6 | VENT 2
1096114 | Nivel 6 | VENT 2
1096118 | Nivel 6 | VENT 2
1096996 | Nivel 1 | AR-DOM 1
1097000 | Nivel 1 | AR-DOM 1
1097004 | Nivel 1 | AR-DOM 1
1097008 | Nivel 2 | AR-DOM 1
1097014 | Nivel 2 | AR-DOM 1
1097016 | Nivel 2 | AR-DOM 1
1097020 | Nivel 2 | AR-DOM 1
1097022 | Nivel 2 | AR-DOM 1
1097044 | Nivel 2 | AR-DOM 1
1097054 | Nivel 2 | AR-DOM 1
1097058 | Nivel 2 | AR-DOM 1
1097066 | Nivel 2 | AR-DOM 1
1097072 | Nivel 2 | AR-DOM 1
1097106 | Nivel 2 | AR-DOM 1
1097112 | Nivel 2 | AR-DOM 1
1097124 | Nivel 2 | AR-DOM 1
1097126 | Nivel 2 | AR-DOM 1
1097130 | Nivel 2 | AR-DOM 1
1097136 | Nivel 1 | AR-DOM 1
1097140 | Nivel 1 | AR-DOM 1
1097146 | Nivel 2 | AR-DOM 1
1097150 | Nivel 2 | AR-DOM 1
1097170 | Nivel 2 | AR-DOM 1
1097174 | Nivel 2 | AR-DOM 1
1097178 | Nivel 2 | AR-DOM 1
1097182 | Nivel 3 | AR-DOM 1
1097188 | Nivel 3 | AR-DOM 1
1097190 | Nivel 3 | AR-DOM 1
1097194 | Nivel 3 | AR-DOM 1
1097196 | Nivel 3 | AR-DOM 1
1097218 | Nivel 3 | AR-DOM 1
1097228 | Nivel 3 | AR-DOM 1
1097232 | Nivel 3 | AR-DOM 1
1097240 | Nivel 3 | AR-DOM 1
1097246 | Nivel 3 | AR-DOM 1
1097280 | Nivel 3 | AR-DOM 1
1097286 | Nivel 3 | AR-DOM 1
1097298 | Nivel 3 | AR-DOM 1
1097300 | Nivel 3 | AR-DOM 1
1097304 | Nivel 3 | AR-DOM 1
1097310 | Nivel 2 | AR-DOM 1
1097314 | Nivel 2 | AR-DOM 1
1097320 | Nivel 3 | AR-DOM 1
1097324 | Nivel 3 | AR-DOM 1
1097340 | Nivel 3 | AR-DOM 1
1097344 | Nivel 3 | AR-DOM 1
1097348 | Nivel 3 | AR-DOM 1
1097352 | Nivel 4 | AR-DOM 1
1097358 | Nivel 4 | AR-DOM 1
1097360 | Nivel 4 | AR-DOM 1
1097364 | Nivel 4 | AR-DOM 1
1097366 | Nivel 4 | AR-DOM 1
1097388 | Nivel 4 | AR-DOM 1
1097396 | Nivel 4 | AR-DOM 1
1097400 | Nivel 4 | AR-DOM 1
1097408 | Nivel 4 | AR-DOM 1
1097414 | Nivel 4 | AR-DOM 1
1097448 | Nivel 4 | AR-DOM 1
1097454 | Nivel 4 | AR-DOM 1
1097466 | Nivel 4 | AR-DOM 1
1097468 | Nivel 4 | AR-DOM 1
1097472 | Nivel 4 | AR-DOM 1
1097478 | Nivel 3 | AR-DOM 1
1097482 | Nivel 3 | AR-DOM 1
1097488 | Nivel 4 | AR-DOM 1
1097492 | Nivel 4 | AR-DOM 1
1097508 | Nivel 4 | AR-DOM 1
1097512 | Nivel 4 | AR-DOM 1
1097516 | Nivel 4 | AR-DOM 1
1097520 | Nivel 5 | AR-DOM 1
1097526 | Nivel 5 | AR-DOM 1
1097528 | Nivel 5 | AR-DOM 1
1097532 | Nivel 5 | AR-DOM 1
1097534 | Nivel 5 | AR-DOM 1
1097556 | Nivel 5 | AR-DOM 1
1097566 | Nivel 5 | AR-DOM 1
1097570 | Nivel 5 | AR-DOM 1
1097578 | Nivel 5 | AR-DOM 1
1097584 | Nivel 5 | AR-DOM 1
1097618 | Nivel 5 | AR-DOM 1
1097624 | Nivel 5 | AR-DOM 1
1097636 | Nivel 5 | AR-DOM 1
1097638 | Nivel 5 | AR-DOM 1
1097642 | Nivel 5 | AR-DOM 1
1097648 | Nivel 4 | AR-DOM 1
1097652 | Nivel 4 | AR-DOM 1
1097658 | Nivel 5 | AR-DOM 1
1097662 | Nivel 5 | AR-DOM 1
1097680 | Nivel 5 | AR-DOM 1
1097684 | Nivel 5 | AR-DOM 1
1097688 | Nivel 5 | AR-DOM 1
1097692 | Nivel 6 | AR-DOM 1
1097698 | Nivel 6 | AR-DOM 1
1097700 | Nivel 6 | AR-DOM 1
1097704 | Nivel 6 | AR-DOM 1
1097706 | Nivel 6 | AR-DOM 1
1097728 | Nivel 6 | AR-DOM 1
1097736 | Nivel 6 | AR-DOM 1
1097740 | Nivel 6 | AR-DOM 1
1097748 | Nivel 6 | AR-DOM 1
1097754 | Nivel 6 | AR-DOM 1
1097786 | Nivel 6 | AR-DOM 1
1097792 | Nivel 6 | AR-DOM 1
1097804 | Nivel 6 | AR-DOM 1
1097806 | Nivel 6 | AR-DOM 1
1097810 | Nivel 6 | AR-DOM 1
1097816 | Nivel 5 | AR-DOM 1
1097820 | Nivel 5 | AR-DOM 1
1097826 | Nivel 6 | AR-DOM 1
1097830 | Nivel 6 | AR-DOM 1
1097856 | Nivel 6 | VENT 3
1097860 | Nivel 6 | VENT 3
1097866 | Nivel 1 | AR-DOM 1
1097870 | Nivel 1 | AR-DOM 1
1097874 | Nivel 1 | AR-DOM 1
1097878 | Nivel 2 | AR-DOM 1
1097884 | Nivel 2 | AR-DOM 1
1097886 | Nivel 2 | AR-DOM 1
1097890 | Nivel 2 | AR-DOM 1
1097892 | Nivel 2 | AR-DOM 1
1097914 | Nivel 2 | AR-DOM 1
1097924 | Nivel 2 | AR-DOM 1
1097928 | Nivel 2 | AR-DOM 1
1097936 | Nivel 2 | AR-DOM 1
1097942 | Nivel 2 | AR-DOM 1
1097976 | Nivel 2 | AR-DOM 1
1097982 | Nivel 2 | AR-DOM 1
1097994 | Nivel 2 | AR-DOM 1
1097996 | Nivel 2 | AR-DOM 1
1098000 | Nivel 2 | AR-DOM 1
1098006 | Nivel 1 | AR-DOM 1
1098010 | Nivel 1 | AR-DOM 1
1098016 | Nivel 2 | AR-DOM 1
1098020 | Nivel 2 | AR-DOM 1
1098040 | Nivel 2 | AR-DOM 1
1098044 | Nivel 2 | AR-DOM 1
1098048 | Nivel 2 | AR-DOM 1
1098052 | Nivel 3 | AR-DOM 1
1098058 | Nivel 3 | AR-DOM 1
1098060 | Nivel 3 | AR-DOM 1
1098064 | Nivel 3 | AR-DOM 1
1098066 | Nivel 3 | AR-DOM 1
1098088 | Nivel 3 | AR-DOM 1
1098098 | Nivel 3 | AR-DOM 1
1098102 | Nivel 3 | AR-DOM 1
1098110 | Nivel 3 | AR-DOM 1
1098116 | Nivel 3 | AR-DOM 1
1098150 | Nivel 3 | AR-DOM 1
1098156 | Nivel 3 | AR-DOM 1
1098168 | Nivel 3 | AR-DOM 1
1098170 | Nivel 3 | AR-DOM 1
1098174 | Nivel 3 | AR-DOM 1
1098180 | Nivel 2 | AR-DOM 1
1098184 | Nivel 2 | AR-DOM 1
1098190 | Nivel 3 | AR-DOM 1
1098194 | Nivel 3 | AR-DOM 1
1098210 | Nivel 3 | AR-DOM 1
1098214 | Nivel 3 | AR-DOM 1
1098218 | Nivel 3 | AR-DOM 1
1098222 | Nivel 4 | AR-DOM 1
1098228 | Nivel 4 | AR-DOM 1
1098230 | Nivel 4 | AR-DOM 1
1098234 | Nivel 4 | AR-DOM 1
1098236 | Nivel 4 | AR-DOM 1
1098258 | Nivel 4 | AR-DOM 1
1098266 | Nivel 4 | AR-DOM 1
1098270 | Nivel 4 | AR-DOM 1
1098278 | Nivel 4 | AR-DOM 1
1098284 | Nivel 4 | AR-DOM 1
1098318 | Nivel 4 | AR-DOM 1
1098324 | Nivel 4 | AR-DOM 1
1098336 | Nivel 4 | AR-DOM 1
1098338 | Nivel 4 | AR-DOM 1
1098342 | Nivel 4 | AR-DOM 1
1098348 | Nivel 3 | AR-DOM 1
1098352 | Nivel 3 | AR-DOM 1
1098358 | Nivel 4 | AR-DOM 1
1098362 | Nivel 4 | AR-DOM 1
1098378 | Nivel 4 | AR-DOM 1
1098382 | Nivel 4 | AR-DOM 1
1098386 | Nivel 4 | AR-DOM 1
1098390 | Nivel 5 | AR-DOM 1
1098396 | Nivel 5 | AR-DOM 1
1098398 | Nivel 5 | AR-DOM 1
1098402 | Nivel 5 | AR-DOM 1
1098404 | Nivel 5 | AR-DOM 1
1098426 | Nivel 5 | AR-DOM 1
1098436 | Nivel 5 | AR-DOM 1
1098440 | Nivel 5 | AR-DOM 1
1098448 | Nivel 5 | AR-DOM 1
1098454 | Nivel 5 | AR-DOM 1
1098488 | Nivel 5 | AR-DOM 1
1098494 | Nivel 5 | AR-DOM 1
1098506 | Nivel 5 | AR-DOM 1
1098508 | Nivel 5 | AR-DOM 1
1098512 | Nivel 5 | AR-DOM 1
1098518 | Nivel 4 | AR-DOM 1
1098522 | Nivel 4 | AR-DOM 1
1098528 | Nivel 5 | AR-DOM 1
1098532 | Nivel 5 | AR-DOM 1
1098550 | Nivel 5 | AR-DOM 1
1098554 | Nivel 5 | AR-DOM 1
1098558 | Nivel 5 | AR-DOM 1
1098562 | Nivel 6 | AR-DOM 1
1098568 | Nivel 6 | AR-DOM 1
1098570 | Nivel 6 | AR-DOM 1
1098574 | Nivel 6 | AR-DOM 1
1098576 | Nivel 6 | AR-DOM 1
1098598 | Nivel 6 | AR-DOM 1
1098606 | Nivel 6 | AR-DOM 1
1098610 | Nivel 6 | AR-DOM 1
1098618 | Nivel 6 | AR-DOM 1
1098624 | Nivel 6 | AR-DOM 1
1098656 | Nivel 6 | AR-DOM 1
1098662 | Nivel 6 | AR-DOM 1
1098674 | Nivel 6 | AR-DOM 1
1098676 | Nivel 6 | AR-DOM 1
1098680 | Nivel 6 | AR-DOM 1
1098686 | Nivel 5 | AR-DOM 1
1098690 | Nivel 5 | AR-DOM 1
1098696 | Nivel 6 | AR-DOM 1
1098700 | Nivel 6 | AR-DOM 1
1098718 | Nivel 6 | VENT 6
1098730 | Nivel 6 | VENT 6
1099130 | Nivel 2 | AR-DOM 1
1099264 | Nivel 1 | VENT 2
1099305 | Nivel 2 | AR-DOM 1
1099557 | Nivel 2 | AR-DOM 1
1099634 | Nivel 2 | VENT 3
1099713 | Nivel 2 | VENT 6
1099806 | Nivel 2 | AR-DOM 1
1244605 | Nivel 1 | AR-DOM 1
1244634 | Nivel 1 | AR-DOM 1
1248604 | Nivel 1 | AR-DOM 4
1248609 | Nivel 1 | AR-DOM 4
1248795 | Nivel 1 | AR-DOM 4
1248805 | Nivel 1 | AR-DOM 4
1248807 | Nivel 1 | AR-DOM 4
1248818 | Nivel 1 | AR-DOM 4
1248828 | Nivel 1 | AR-DOM 4
1248830 | Nivel 1 | AR-DOM 4
1248839 | Nivel 1 | AR-DOM 4
1248849 | Nivel 1 | AR-DOM 4
1248851 | Nivel 1 | AR-DOM 4
1345659 | Nivel 6 | VENT 6
1345971 | Nivel 6 | VENT 1
1346011 | Nivel 6 | VENT 1
1346091 | Nivel 6 | VENT 2
1346126 | Nivel 6 | VENT 2
1346242 | Nivel 6 | VENT 3
1346418 | Nivel 7 | VENT 3
1346491 | Nivel 6 | VENT 6
1346527 | Nivel 6 | VENT 6
1486507 | Nivel 6 | VENT 3
1486827 | Nivel 1 | ALL 1

# IfcPipeFitting: D2020 - Codo CxE PVC.S:Standard (40)
Type - Material: PVC
Classification: 21.04.20.20.30 Uniformat (Uniformat); Group: AR-DOM 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2020 - Codo CxE PVC.S:Standard:...) | In
949087 | Nivel 2
950716 | Nivel 2
1092027 | Nivel 3
1092041 | Nivel 3
1092436 | Nivel 4
1092450 | Nivel 4
1092844 | Nivel 5
1092858 | Nivel 5
1093252 | Nivel 6
1093266 | Nivel 6
1095306 | Nivel 2
1095320 | Nivel 2
1095480 | Nivel 3
1095494 | Nivel 3
1095650 | Nivel 4
1095662 | Nivel 4
1095818 | Nivel 5
1095832 | Nivel 5
1095990 | Nivel 6
1096002 | Nivel 6
1097048 | Nivel 2
1097062 | Nivel 2
1097222 | Nivel 3
1097236 | Nivel 3
1097392 | Nivel 4
1097404 | Nivel 4
1097560 | Nivel 5
1097574 | Nivel 5
1097732 | Nivel 6
1097744 | Nivel 6
1097918 | Nivel 2
1097932 | Nivel 2
1098092 | Nivel 3
1098106 | Nivel 3
1098262 | Nivel 4
1098274 | Nivel 4
1098430 | Nivel 5
1098444 | Nivel 5
1098602 | Nivel 6
1098614 | Nivel 6

# IfcPipeFitting: D2020 - Junta Expansion PVC.S:Standard, D2020 - Junta Expansion PVC.S:Standard:1486476
In: Nivel 6
Type - Material: PVC
Classification: D2020 Uniformat (Uniformat); Group: VENT 3
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Qto_PipeFittingBaseQuantities - Length: 0.19463 m

# IfcPipeFitting: D2020 - Sifon CxE PVC.S:Standard (76)
Type - Material: PVC
Classification: 21.04.20.20.30 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2020 - Sifon CxE PVC.S:Standard:...) | In | Group
953092 | Nivel 2 | AR-DOM 1
953902 | Nivel 2 | AR-DOM 1
956079 | Nivel 2 | AR-DOM 1
1069349 | Nivel 1 | AR-DOM 4
1073542 | Nivel 1 | AR-DOM 4
1073698 | Nivel 1 | AR-DOM 4
1075143 | Nivel 1 | AR-DOM 4
1075315 | Nivel 1 | AR-DOM 4
1075317 | Nivel 1 | AR-DOM 4
1092055 | Nivel 3 | AR-DOM 1
1092075 | Nivel 3 | AR-DOM 1
1092107 | Nivel 3 | AR-DOM 1
1092464 | Nivel 4 | AR-DOM 1
1092484 | Nivel 4 | AR-DOM 1
1092516 | Nivel 4 | AR-DOM 1
1092872 | Nivel 5 | AR-DOM 1
1092892 | Nivel 5 | AR-DOM 1
1092924 | Nivel 5 | AR-DOM 1
1093280 | Nivel 6 | AR-DOM 1
1093300 | Nivel 6 | AR-DOM 1
1093332 | Nivel 6 | AR-DOM 1
1095334 | Nivel 2 | AR-DOM 1
1095354 | Nivel 2 | AR-DOM 1
1095386 | Nivel 2 | AR-DOM 1
1095508 | Nivel 3 | AR-DOM 1
1095528 | Nivel 3 | AR-DOM 1
1095560 | Nivel 3 | AR-DOM 1
1095676 | Nivel 4 | AR-DOM 1
1095696 | Nivel 4 | AR-DOM 1
1095728 | Nivel 4 | AR-DOM 1
1095846 | Nivel 5 | AR-DOM 1
1095866 | Nivel 5 | AR-DOM 1
1095898 | Nivel 5 | AR-DOM 1
1096016 | Nivel 6 | AR-DOM 1
1096034 | Nivel 6 | AR-DOM 1
1096066 | Nivel 6 | AR-DOM 1
1097076 | Nivel 2 | AR-DOM 1
1097096 | Nivel 2 | AR-DOM 1
1097128 | Nivel 2 | AR-DOM 1
1097250 | Nivel 3 | AR-DOM 1
1097270 | Nivel 3 | AR-DOM 1
1097302 | Nivel 3 | AR-DOM 1
1097418 | Nivel 4 | AR-DOM 1
1097438 | Nivel 4 | AR-DOM 1
1097470 | Nivel 4 | AR-DOM 1
1097588 | Nivel 5 | AR-DOM 1
1097608 | Nivel 5 | AR-DOM 1
1097640 | Nivel 5 | AR-DOM 1
1097758 | Nivel 6 | AR-DOM 1
1097776 | Nivel 6 | AR-DOM 1
1097808 | Nivel 6 | AR-DOM 1
1097946 | Nivel 2 | AR-DOM 1
1097966 | Nivel 2 | AR-DOM 1
1097998 | Nivel 2 | AR-DOM 1
1098120 | Nivel 3 | AR-DOM 1
1098140 | Nivel 3 | AR-DOM 1
1098172 | Nivel 3 | AR-DOM 1
1098288 | Nivel 4 | AR-DOM 1
1098308 | Nivel 4 | AR-DOM 1
1098340 | Nivel 4 | AR-DOM 1
1098458 | Nivel 5 | AR-DOM 1
1098478 | Nivel 5 | AR-DOM 1
1098510 | Nivel 5 | AR-DOM 1
1098628 | Nivel 6 | AR-DOM 1
1098646 | Nivel 6 | AR-DOM 1
1098678 | Nivel 6 | AR-DOM 1
1106932 | Nivel 1 | AR-DOM 4
1107072 | Nivel 1 | AR-DOM 4
1246915 | Nivel 1 | AR-DOM 4
1247090 | Nivel 1 | AR-DOM 4
1247107 | Nivel 1 | AR-DOM 4
1247122 | Nivel 1 | AR-DOM 4
1247682 | Nivel 1 | AR-DOM 4
1248801 | Nivel 1 | AR-DOM 4
1248824 | Nivel 1 | AR-DOM 4
1248845 | Nivel 1 | AR-DOM 4

# IfcPipeFitting: D2020 - Tapon PVC.LL:Standard (5)
In: Nivel 1
Type - PredefinedType: BEND; Material: <Unnamed>
Classification: 21.04.20.30.20 Uniformat (Uniformat); Group: ALL 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2020 - Tapon PVC.LL:Standard:...)
1085350
1089705
1200699
1220184
1220191

# IfcPipeFitting: D2020 - Tapon PVC.S:Standard (172)
Type - Material: <Unnamed>
Classification: 21.04.20.20.30 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2020 - Tapon PVC.S:Standard:...) | In | Group
954305 | Nivel 2 | AR-DOM 1
954318 | Nivel 2 | AR-DOM 1
954380 | Nivel 2 | AR-DOM 1
956455 | Nivel 1 | AR-DOM 1
957209 | Nivel 2 | AR-DOM 1
957461 | Nivel 2 | AR-DOM 1
957467 | Nivel 2 | AR-DOM 1
1067394 | Nivel 1 | AR-DOM 4
1068230 | Nivel 1 | AR-DOM 4
1069625 | Nivel 1 | AR-DOM 4
1070172 | Nivel 1 | AR-DOM 4
1070656 | Nivel 1 | AR-DOM 4
1071252 | Nivel 1 | AR-DOM 4
1072163 | Nivel 1 | AR-DOM 4
1073879 | Nivel 1 | AR-DOM 4
1074018 | Nivel 1 | AR-DOM 4
1074881 | Nivel 1 | AR-DOM 4
1074959 | Nivel 1 | AR-DOM 4
1075099 | Nivel 1 | AR-DOM 4
1075109 | Nivel 1 | AR-DOM 4
1075159 | Nivel 1 | AR-DOM 4
1075183 | Nivel 1 | AR-DOM 4
1075201 | Nivel 1 | AR-DOM 4
1075323 | Nivel 1 | AR-DOM 4
1075329 | Nivel 1 | AR-DOM 4
1075479 | Nivel 1 | AR-DOM 4
1075680 | Nivel 1 | AR-DOM 4
1075788 | Nivel 1 | AR-DOM 4
1075845 | Nivel 1 | AR-DOM 4
1088122 | Nivel 1 | AR-DOM 4
1092081 | Nivel 3 | AR-DOM 1
1092083 | Nivel 3 | AR-DOM 1
1092093 | Nivel 3 | AR-DOM 1
1092121 | Nivel 2 | AR-DOM 1
1092131 | Nivel 3 | AR-DOM 1
1092137 | Nivel 3 | AR-DOM 1
1092139 | Nivel 3 | AR-DOM 1
1092490 | Nivel 4 | AR-DOM 1
1092492 | Nivel 4 | AR-DOM 1
1092502 | Nivel 4 | AR-DOM 1
1092530 | Nivel 3 | AR-DOM 1
1092540 | Nivel 4 | AR-DOM 1
1092546 | Nivel 4 | AR-DOM 1
1092548 | Nivel 4 | AR-DOM 1
1092898 | Nivel 5 | AR-DOM 1
1092900 | Nivel 5 | AR-DOM 1
1092910 | Nivel 5 | AR-DOM 1
1092938 | Nivel 4 | AR-DOM 1
1092948 | Nivel 5 | AR-DOM 1
1092954 | Nivel 5 | AR-DOM 1
1092956 | Nivel 5 | AR-DOM 1
1093306 | Nivel 6 | AR-DOM 1
1093308 | Nivel 6 | AR-DOM 1
1093318 | Nivel 6 | AR-DOM 1
1093346 | Nivel 5 | AR-DOM 1
1093356 | Nivel 6 | AR-DOM 1
1093362 | Nivel 6 | AR-DOM 1
1093364 | Nivel 6 | AR-DOM 1
1095360 | Nivel 2 | AR-DOM 1
1095362 | Nivel 2 | AR-DOM 1
1095372 | Nivel 2 | AR-DOM 1
1095400 | Nivel 1 | AR-DOM 1
1095410 | Nivel 2 | AR-DOM 1
1095416 | Nivel 2 | AR-DOM 1
1095418 | Nivel 2 | AR-DOM 1
1095534 | Nivel 3 | AR-DOM 1
1095536 | Nivel 3 | AR-DOM 1
1095546 | Nivel 3 | AR-DOM 1
1095574 | Nivel 2 | AR-DOM 1
1095584 | Nivel 3 | AR-DOM 1
1095590 | Nivel 3 | AR-DOM 1
1095592 | Nivel 3 | AR-DOM 1
1095702 | Nivel 4 | AR-DOM 1
1095704 | Nivel 4 | AR-DOM 1
1095714 | Nivel 4 | AR-DOM 1
1095742 | Nivel 3 | AR-DOM 1
1095752 | Nivel 4 | AR-DOM 1
1095758 | Nivel 4 | AR-DOM 1
1095760 | Nivel 4 | AR-DOM 1
1095872 | Nivel 5 | AR-DOM 1
1095874 | Nivel 5 | AR-DOM 1
1095884 | Nivel 5 | AR-DOM 1
1095912 | Nivel 4 | AR-DOM 1
1095922 | Nivel 5 | AR-DOM 1
1095928 | Nivel 5 | AR-DOM 1
1095930 | Nivel 5 | AR-DOM 1
1096040 | Nivel 6 | AR-DOM 1
1096042 | Nivel 6 | AR-DOM 1
1096052 | Nivel 6 | AR-DOM 1
1096080 | Nivel 5 | AR-DOM 1
1096090 | Nivel 6 | AR-DOM 1
1096096 | Nivel 6 | AR-DOM 1
1096098 | Nivel 6 | AR-DOM 1
1097102 | Nivel 2 | AR-DOM 1
1097104 | Nivel 2 | AR-DOM 1
1097114 | Nivel 2 | AR-DOM 1
1097142 | Nivel 1 | AR-DOM 1
1097152 | Nivel 2 | AR-DOM 1
1097158 | Nivel 2 | AR-DOM 1
1097160 | Nivel 2 | AR-DOM 1
1097276 | Nivel 3 | AR-DOM 1
1097278 | Nivel 3 | AR-DOM 1
1097288 | Nivel 3 | AR-DOM 1
1097316 | Nivel 2 | AR-DOM 1
1097326 | Nivel 3 | AR-DOM 1
1097332 | Nivel 3 | AR-DOM 1
1097334 | Nivel 3 | AR-DOM 1
1097444 | Nivel 4 | AR-DOM 1
1097446 | Nivel 4 | AR-DOM 1
1097456 | Nivel 4 | AR-DOM 1
1097484 | Nivel 3 | AR-DOM 1
1097494 | Nivel 4 | AR-DOM 1
1097500 | Nivel 4 | AR-DOM 1
1097502 | Nivel 4 | AR-DOM 1
1097614 | Nivel 5 | AR-DOM 1
1097616 | Nivel 5 | AR-DOM 1
1097626 | Nivel 5 | AR-DOM 1
1097654 | Nivel 4 | AR-DOM 1
1097664 | Nivel 5 | AR-DOM 1
1097670 | Nivel 5 | AR-DOM 1
1097672 | Nivel 5 | AR-DOM 1
1097782 | Nivel 6 | AR-DOM 1
1097784 | Nivel 6 | AR-DOM 1
1097794 | Nivel 6 | AR-DOM 1
1097822 | Nivel 5 | AR-DOM 1
1097832 | Nivel 6 | AR-DOM 1
1097838 | Nivel 6 | AR-DOM 1
1097840 | Nivel 6 | AR-DOM 1
1097972 | Nivel 2 | AR-DOM 1
1097974 | Nivel 2 | AR-DOM 1
1097984 | Nivel 2 | AR-DOM 1
1098012 | Nivel 1 | AR-DOM 1
1098022 | Nivel 2 | AR-DOM 1
1098028 | Nivel 2 | AR-DOM 1
1098030 | Nivel 2 | AR-DOM 1
1098146 | Nivel 3 | AR-DOM 1
1098148 | Nivel 3 | AR-DOM 1
1098158 | Nivel 3 | AR-DOM 1
1098186 | Nivel 2 | AR-DOM 1
1098196 | Nivel 3 | AR-DOM 1
1098202 | Nivel 3 | AR-DOM 1
1098204 | Nivel 3 | AR-DOM 1
1098314 | Nivel 4 | AR-DOM 1
1098316 | Nivel 4 | AR-DOM 1
1098326 | Nivel 4 | AR-DOM 1
1098354 | Nivel 3 | AR-DOM 1
1098364 | Nivel 4 | AR-DOM 1
1098370 | Nivel 4 | AR-DOM 1
1098372 | Nivel 4 | AR-DOM 1
1098484 | Nivel 5 | AR-DOM 1
1098486 | Nivel 5 | AR-DOM 1
1098496 | Nivel 5 | AR-DOM 1
1098524 | Nivel 4 | AR-DOM 1
1098534 | Nivel 5 | AR-DOM 1
1098540 | Nivel 5 | AR-DOM 1
1098542 | Nivel 5 | AR-DOM 1
1098652 | Nivel 6 | AR-DOM 1
1098654 | Nivel 6 | AR-DOM 1
1098664 | Nivel 6 | AR-DOM 1
1098692 | Nivel 5 | AR-DOM 1
1098702 | Nivel 6 | AR-DOM 1
1098708 | Nivel 6 | AR-DOM 1
1098710 | Nivel 6 | AR-DOM 1
1106936 | Nivel 1 | AR-DOM 4
1107076 | Nivel 1 | AR-DOM 4
1247094 | Nivel 1 | AR-DOM 4
1247111 | Nivel 1 | AR-DOM 4
1247126 | Nivel 1 | AR-DOM 4
1248797 | Nivel 1 | AR-DOM 4
1248820 | Nivel 1 | AR-DOM 4
1248841 | Nivel 1 | AR-DOM 4
1331835 | Nivel 1 | ALL 1

# IfcPipeFitting: D2020 - Tee PVC.S:Standard (20)
Type - Material: <Unnamed>
Classification: 21.04.20.20.30 Uniformat (Uniformat); Group: AR-DOM 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2020 - Tee PVC.S:Standard:...) | In
949497 | Nivel 2
1092031 | Nivel 3
1092440 | Nivel 4
1092848 | Nivel 5
1093256 | Nivel 6
1095310 | Nivel 2
1095484 | Nivel 3
1095652 | Nivel 4
1095822 | Nivel 5
1095992 | Nivel 6
1097052 | Nivel 2
1097226 | Nivel 3
1097394 | Nivel 4
1097564 | Nivel 5
1097734 | Nivel 6
1097922 | Nivel 2
1098096 | Nivel 3
1098264 | Nivel 4
1098434 | Nivel 5
1098604 | Nivel 6

# IfcPipeFitting: D2020 - Tee Reducida PVC.S:Standard (40)
Type - Material: <Unnamed>
Classification: 21.04.20.20.30 Uniformat (Uniformat); Group: AR-DOM 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2020 - Tee Reducida PVC.S:Standard:...) | In
953329 | Nivel 2
955408 | Nivel 2
1092057 | Nivel 3
1092097 | Nivel 3
1092466 | Nivel 4
1092506 | Nivel 4
1092874 | Nivel 5
1092914 | Nivel 5
1093282 | Nivel 6
1093322 | Nivel 6
1095336 | Nivel 2
1095376 | Nivel 2
1095510 | Nivel 3
1095550 | Nivel 3
1095678 | Nivel 4
1095718 | Nivel 4
1095848 | Nivel 5
1095888 | Nivel 5
1096018 | Nivel 6
1096056 | Nivel 6
1097078 | Nivel 2
1097118 | Nivel 2
1097252 | Nivel 3
1097292 | Nivel 3
1097420 | Nivel 4
1097460 | Nivel 4
1097590 | Nivel 5
1097630 | Nivel 5
1097760 | Nivel 6
1097798 | Nivel 6
1097948 | Nivel 2
1097988 | Nivel 2
1098122 | Nivel 3
1098162 | Nivel 3
1098290 | Nivel 4
1098330 | Nivel 4
1098460 | Nivel 5
1098500 | Nivel 5
1098630 | Nivel 6
1098668 | Nivel 6

# IfcPipeFitting: D2020 - Yee PVC.LL:Standard (5)
In: Nivel 1
Type - Material: <Unnamed>
Classification: 21.04.20.30.20 Uniformat (Uniformat); Group: ALL 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2020 - Yee PVC.LL:Standard:...)
1084462
1086151
1199775
1200227
1331648

# IfcPipeFitting: D2020 - Yee PVC.S:Standard (88)
Type - Material: <Unnamed>
Classification: 21.04.20.20.30 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2020 - Yee PVC.S:Standard:...) | In | Group
948534 | Nivel 2 | AR-DOM 1
948784 | Nivel 2 | AR-DOM 1
953789 | Nivel 2 | VENT 1
1068189 | Nivel 1 | AR-DOM 4
1068575 | Nivel 1 | AR-DOM 4
1071573 | Nivel 1 | AR-DOM 4
1072642 | Nivel 1 | AR-DOM 4
1072674 | Nivel 1 | AR-DOM 4
1072908 | Nivel 1 | AR-DOM 4
1073112 | Nivel 1 | AR-DOM 4
1075103 | Nivel 1 | AR-DOM 4
1075119 | Nivel 1 | AR-DOM 4
1075223 | Nivel 1 | AR-DOM 4
1075277 | Nivel 1 | AR-DOM 4
1075283 | Nivel 1 | AR-DOM 4
1075295 | Nivel 1 | AR-DOM 4
1075309 | Nivel 1 | AR-DOM 4
1076020 | Nivel 1 | AR-DOM 4
1078162 | Nivel 1 | AR-DOM 1
1078549 | Nivel 1 | AR-DOM 1
1081490 | Nivel 1 | AR-DOM 4
1081998 | Nivel 1 | AR-DOM 4
1082891 | Nivel 1 | AR-DOM 4
1082989 | Nivel 1 | AR-DOM 4
1083135 | Nivel 1 | AR-DOM 4
1083268 | Nivel 1 | AR-DOM 4
1092007 | Nivel 3 | AR-DOM 1
1092015 | Nivel 3 | AR-DOM 1
1092073 | Nivel 3 | VENT 1
1092416 | Nivel 4 | AR-DOM 1
1092424 | Nivel 4 | AR-DOM 1
1092482 | Nivel 4 | VENT 1
1092824 | Nivel 5 | AR-DOM 1
1092832 | Nivel 5 | AR-DOM 1
1092890 | Nivel 5 | VENT 1
1093232 | Nivel 6 | AR-DOM 1
1093240 | Nivel 6 | AR-DOM 1
1093298 | Nivel 6 | VENT 1
1095286 | Nivel 2 | AR-DOM 1
1095294 | Nivel 2 | AR-DOM 1
1095352 | Nivel 2 | VENT 2
1095460 | Nivel 3 | AR-DOM 1
1095468 | Nivel 3 | AR-DOM 1
1095526 | Nivel 3 | VENT 2
1095630 | Nivel 4 | AR-DOM 1
1095638 | Nivel 4 | AR-DOM 1
1095694 | Nivel 4 | VENT 2
1095798 | Nivel 5 | AR-DOM 1
1095806 | Nivel 5 | AR-DOM 1
1095864 | Nivel 5 | VENT 2
1095970 | Nivel 6 | AR-DOM 1
1095978 | Nivel 6 | AR-DOM 1
1096032 | Nivel 6 | VENT 2
1097028 | Nivel 2 | AR-DOM 1
1097036 | Nivel 2 | AR-DOM 1
1097094 | Nivel 2 | VENT 3
1097202 | Nivel 3 | AR-DOM 1
1097210 | Nivel 3 | AR-DOM 1
1097268 | Nivel 3 | VENT 3
1097372 | Nivel 4 | AR-DOM 1
1097380 | Nivel 4 | AR-DOM 1
1097436 | Nivel 4 | VENT 3
1097540 | Nivel 5 | AR-DOM 1
1097548 | Nivel 5 | AR-DOM 1
1097606 | Nivel 5 | VENT 3
1097712 | Nivel 6 | AR-DOM 1
1097720 | Nivel 6 | AR-DOM 1
1097774 | Nivel 6 | VENT 3
1097898 | Nivel 2 | AR-DOM 1
1097906 | Nivel 2 | AR-DOM 1
1097964 | Nivel 2 | VENT 6
1098072 | Nivel 3 | AR-DOM 1
1098080 | Nivel 3 | AR-DOM 1
1098138 | Nivel 3 | VENT 6
1098242 | Nivel 4 | AR-DOM 1
1098250 | Nivel 4 | AR-DOM 1
1098306 | Nivel 4 | VENT 6
1098410 | Nivel 5 | AR-DOM 1
1098418 | Nivel 5 | AR-DOM 1
1098476 | Nivel 5 | VENT 6
1098582 | Nivel 6 | AR-DOM 1
1098590 | Nivel 6 | AR-DOM 1
1098644 | Nivel 6 | VENT 6
1244552 | Nivel 1 | AR-DOM 1
1246861 | Nivel 1 | AR-DOM 4
1247007 | Nivel 1 | AR-DOM 4
1247215 | Nivel 1 | AR-DOM 4
1247353 | Nivel 1 | AR-DOM 4

# IfcPipeFitting: D2020 - Yee Reducida PVC.LL:Standard (2)
In: Nivel 1
Type - Material: <Unnamed>
Classification: 21.04.20.30.20 Uniformat (Uniformat); Group: ALL 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2020 - Yee Reducida PVC.LL:Standard:...)
1089493
1246306

# IfcPipeFitting: D2020 - Yee Reducida PVC.S:Standard (73)
Type - Material: <Unnamed>
Classification: 21.04.20.20.30 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2020 - Yee Reducida PVC.S:Standard:...) | In | Group
950667 | Nivel 2 | AR-DOM 1
953382 | Nivel 2 | AR-DOM 1
953533 | Nivel 2 | AR-DOM 1
1068419 | Nivel 1 | AR-DOM 4
1069534 | Nivel 1 | AR-DOM 4
1072431 | Nivel 1 | AR-DOM 4
1075113 | Nivel 1 | AR-DOM 4
1075153 | Nivel 1 | AR-DOM 4
1075261 | Nivel 1 | AR-DOM 4
1081044 | Nivel 1 | AR-DOM 4
1082264 | Nivel 1 | AR-DOM 4
1092039 | Nivel 3 | AR-DOM 1
1092063 | Nivel 3 | AR-DOM 1
1092067 | Nivel 3 | AR-DOM 1
1092448 | Nivel 4 | AR-DOM 1
1092472 | Nivel 4 | AR-DOM 1
1092476 | Nivel 4 | AR-DOM 1
1092856 | Nivel 5 | AR-DOM 1
1092880 | Nivel 5 | AR-DOM 1
1092884 | Nivel 5 | AR-DOM 1
1093264 | Nivel 6 | AR-DOM 1
1093288 | Nivel 6 | AR-DOM 1
1093292 | Nivel 6 | AR-DOM 1
1093897 | Nivel 6 | VENT 1
1095318 | Nivel 2 | AR-DOM 1
1095342 | Nivel 2 | AR-DOM 1
1095346 | Nivel 2 | AR-DOM 1
1095492 | Nivel 3 | AR-DOM 1
1095516 | Nivel 3 | AR-DOM 1
1095520 | Nivel 3 | AR-DOM 1
1095660 | Nivel 4 | AR-DOM 1
1095684 | Nivel 4 | AR-DOM 1
1095688 | Nivel 4 | AR-DOM 1
1095830 | Nivel 5 | AR-DOM 1
1095854 | Nivel 5 | AR-DOM 1
1095858 | Nivel 5 | AR-DOM 1
1096000 | Nivel 6 | AR-DOM 1
1096024 | Nivel 6 | AR-DOM 1
1096026 | Nivel 6 | AR-DOM 1
1096108 | Nivel 6 | VENT 2
1097060 | Nivel 2 | AR-DOM 1
1097084 | Nivel 2 | AR-DOM 1
1097088 | Nivel 2 | AR-DOM 1
1097234 | Nivel 3 | AR-DOM 1
1097258 | Nivel 3 | AR-DOM 1
1097262 | Nivel 3 | AR-DOM 1
1097402 | Nivel 4 | AR-DOM 1
1097426 | Nivel 4 | AR-DOM 1
1097430 | Nivel 4 | AR-DOM 1
1097572 | Nivel 5 | AR-DOM 1
1097596 | Nivel 5 | AR-DOM 1
1097600 | Nivel 5 | AR-DOM 1
1097742 | Nivel 6 | AR-DOM 1
1097766 | Nivel 6 | AR-DOM 1
1097768 | Nivel 6 | AR-DOM 1
1097930 | Nivel 2 | AR-DOM 1
1097954 | Nivel 2 | AR-DOM 1
1097958 | Nivel 2 | AR-DOM 1
1098104 | Nivel 3 | AR-DOM 1
1098128 | Nivel 3 | AR-DOM 1
1098132 | Nivel 3 | AR-DOM 1
1098272 | Nivel 4 | AR-DOM 1
1098296 | Nivel 4 | AR-DOM 1
1098300 | Nivel 4 | AR-DOM 1
1098442 | Nivel 5 | AR-DOM 1
1098466 | Nivel 5 | AR-DOM 1
1098470 | Nivel 5 | AR-DOM 1
1098612 | Nivel 6 | AR-DOM 1
1098636 | Nivel 6 | AR-DOM 1
1098638 | Nivel 6 | AR-DOM 1
1098720 | Nivel 6 | VENT 6
1106899 | Nivel 1 | AR-DOM 4
1107053 | Nivel 1 | AR-DOM 4

# IfcPipeFitting: D2060 - Codo POLIETILENO:Standard, D2060 - Codo POLIETILENO:Standard:1311139
In: Nivel 1
Type - Material: <Unnamed>
Classification: 21.04.20.60.30 Uniformat (Uniformat); Group: GAS 27
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2

# IfcPipeFitting: D2060 - Codo roscado:Standard (411)
Type - Material: <Unnamed>
Classification: 21.04.20.60.30 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2060 - Codo roscado:Standard:...) | In | Group
1059527 | Nivel 1 | GAS 2
1060604 | Nivel 1 | GAS 2
1060745 | Nivel 6 | GAS 2
1060777 | Nivel 2 | GAS 2
1060813 | Nivel 3 | GAS 2
1060849 | Nivel 4 | GAS 2
1060885 | Nivel 5 | GAS 2
1060925 | Nivel 6 | GAS 2
1105028 | Nivel 1 | GAS 5
1105030 | Nivel 1 | GAS 5
1105042 | Nivel 1 | GAS 5
1105050 | Nivel 1 | GAS 5
1105054 | Nivel 1 | GAS 5
1105058 | Nivel 1 | GAS 5
1105062 | Nivel 1 | GAS 5
1105064 | Nivel 1 | GAS 5
1105075 | Nivel 1 | GAS 5
1105077 | Nivel 1 | GAS 5
1105079 | Nivel 1 | GAS 5
1105081 | Nivel 1 | GAS 5
1105088 | Nivel 1 | GAS 5
1105092 | Nivel 1 | GAS 5
1118185 | Nivel 1 | GAS 6
1118187 | Nivel 1 | GAS 6
1118199 | Nivel 1 | GAS 6
1118207 | Nivel 1 | GAS 6
1118211 | Nivel 1 | GAS 6
1118215 | Nivel 1 | GAS 6
1118219 | Nivel 1 | GAS 6
1118221 | Nivel 1 | GAS 6
1118232 | Nivel 1 | GAS 6
1118234 | Nivel 1 | GAS 6
1118236 | Nivel 1 | GAS 6
1118238 | Nivel 1 | GAS 6
1118245 | Nivel 1 | GAS 6
1118249 | Nivel 1 | GAS 6
1118261 | Nivel 1 | GAS 8
1118263 | Nivel 1 | GAS 8
1118275 | Nivel 1 | GAS 8
1118283 | Nivel 1 | GAS 8
1118287 | Nivel 1 | GAS 8
1118291 | Nivel 1 | GAS 8
1118295 | Nivel 1 | GAS 8
1118297 | Nivel 1 | GAS 8
1118308 | Nivel 1 | GAS 8
1118310 | Nivel 1 | GAS 8
1118312 | Nivel 1 | GAS 8
1118314 | Nivel 1 | GAS 8
1118321 | Nivel 1 | GAS 8
1118325 | Nivel 1 | GAS 8
1118337 | Nivel 1 | GAS 9
1118339 | Nivel 1 | GAS 9
1118351 | Nivel 1 | GAS 9
1118359 | Nivel 1 | GAS 9
1118363 | Nivel 1 | GAS 9
1118367 | Nivel 1 | GAS 9
1118371 | Nivel 1 | GAS 9
1118373 | Nivel 1 | GAS 9
1118384 | Nivel 1 | GAS 9
1118386 | Nivel 1 | GAS 9
1118388 | Nivel 1 | GAS 9
1118390 | Nivel 1 | GAS 9
1118397 | Nivel 1 | GAS 9
1118401 | Nivel 1 | GAS 9
1118466 | Nivel 1 | GAS 6
1118513 | Nivel 1 | GAS 5
1118590 | Nivel 1 | GAS 9
1118622 | Nivel 1 | GAS 8
1118632 | Nivel 1 | GAS 8
1118640 | Nivel 1 | GAS 8
1118823 | Nivel 1 | GAS 6
1118853 | Nivel 1 | GAS 5
1118885 | Nivel 1 | GAS 9
1118915 | Nivel 1 | GAS 8
1191995 | Nivel 2 | GAS 1
1191997 | Nivel 2 | GAS 1
1192009 | Nivel 2 | GAS 1
1192017 | Nivel 2 | GAS 1
1192021 | Nivel 2 | GAS 1
1192025 | Nivel 2 | GAS 1
1192029 | Nivel 2 | GAS 1
1192031 | Nivel 2 | GAS 1
1192042 | Nivel 2 | GAS 1
1192044 | Nivel 2 | GAS 1
1192046 | Nivel 2 | GAS 1
1192048 | Nivel 2 | GAS 1
1192055 | Nivel 2 | GAS 1
1192059 | Nivel 2 | GAS 1
1192067 | Nivel 2 | GAS 4
1192069 | Nivel 2 | GAS 4
1192081 | Nivel 2 | GAS 4
1192089 | Nivel 2 | GAS 4
1192093 | Nivel 2 | GAS 4
1192097 | Nivel 2 | GAS 4
1192101 | Nivel 2 | GAS 4
1192103 | Nivel 2 | GAS 4
1192114 | Nivel 2 | GAS 4
1192116 | Nivel 2 | GAS 4
1192118 | Nivel 2 | GAS 4
1192120 | Nivel 2 | GAS 4
1192127 | Nivel 2 | GAS 4
1192131 | Nivel 2 | GAS 4
1192139 | Nivel 2 | GAS 10
1192141 | Nivel 2 | GAS 10
1192153 | Nivel 2 | GAS 10
1192161 | Nivel 2 | GAS 10
1192165 | Nivel 2 | GAS 10
1192169 | Nivel 2 | GAS 10
1192173 | Nivel 2 | GAS 10
1192175 | Nivel 2 | GAS 10
1192186 | Nivel 2 | GAS 10
1192188 | Nivel 2 | GAS 10
1192190 | Nivel 2 | GAS 10
1192192 | Nivel 2 | GAS 10
1192199 | Nivel 2 | GAS 10
1192203 | Nivel 2 | GAS 10
1192209 | Nivel 2 | GAS 12
1192211 | Nivel 2 | GAS 12
1192223 | Nivel 2 | GAS 12
1192231 | Nivel 2 | GAS 12
1192235 | Nivel 2 | GAS 12
1192239 | Nivel 2 | GAS 12
1192243 | Nivel 2 | GAS 12
1192245 | Nivel 2 | GAS 12
1192256 | Nivel 2 | GAS 12
1192258 | Nivel 2 | GAS 12
1192260 | Nivel 2 | GAS 12
1192262 | Nivel 2 | GAS 12
1192269 | Nivel 2 | GAS 12
1192273 | Nivel 2 | GAS 12
1192279 | Nivel 2 | GAS 4
1192283 | Nivel 2 | GAS 1
1192289 | Nivel 2 | GAS 12
1192293 | Nivel 2 | GAS 10
1192297 | Nivel 2 | GAS 10
1192301 | Nivel 2 | GAS 10
1192305 | Nivel 2 | GAS 4
1192309 | Nivel 2 | GAS 1
1192313 | Nivel 2 | GAS 12
1192317 | Nivel 2 | GAS 10
1192353 | Nivel 3 | GAS 3
1192355 | Nivel 3 | GAS 3
1192367 | Nivel 3 | GAS 3
1192375 | Nivel 3 | GAS 3
1192379 | Nivel 3 | GAS 3
1192383 | Nivel 3 | GAS 3
1192387 | Nivel 3 | GAS 3
1192389 | Nivel 3 | GAS 3
1192400 | Nivel 3 | GAS 3
1192402 | Nivel 3 | GAS 3
1192404 | Nivel 3 | GAS 3
1192406 | Nivel 3 | GAS 3
1192413 | Nivel 3 | GAS 3
1192417 | Nivel 3 | GAS 3
1192425 | Nivel 3 | GAS 11
1192427 | Nivel 3 | GAS 11
1192439 | Nivel 3 | GAS 11
1192447 | Nivel 3 | GAS 11
1192451 | Nivel 3 | GAS 11
1192455 | Nivel 3 | GAS 11
1192459 | Nivel 3 | GAS 11
1192461 | Nivel 3 | GAS 11
1192472 | Nivel 3 | GAS 11
1192474 | Nivel 3 | GAS 11
1192476 | Nivel 3 | GAS 11
1192478 | Nivel 3 | GAS 11
1192485 | Nivel 3 | GAS 11
1192489 | Nivel 3 | GAS 11
1192497 | Nivel 3 | GAS 14
1192499 | Nivel 3 | GAS 14
1192511 | Nivel 3 | GAS 14
1192519 | Nivel 3 | GAS 14
1192523 | Nivel 3 | GAS 14
1192527 | Nivel 3 | GAS 14
1192531 | Nivel 3 | GAS 14
1192533 | Nivel 3 | GAS 14
1192544 | Nivel 3 | GAS 14
1192546 | Nivel 3 | GAS 14
1192548 | Nivel 3 | GAS 14
1192550 | Nivel 3 | GAS 14
1192557 | Nivel 3 | GAS 14
1192561 | Nivel 3 | GAS 14
1192567 | Nivel 3 | GAS 16
1192569 | Nivel 3 | GAS 16
1192581 | Nivel 3 | GAS 16
1192589 | Nivel 3 | GAS 16
1192593 | Nivel 3 | GAS 16
1192597 | Nivel 3 | GAS 16
1192601 | Nivel 3 | GAS 16
1192603 | Nivel 3 | GAS 16
1192614 | Nivel 3 | GAS 16
1192616 | Nivel 3 | GAS 16
1192618 | Nivel 3 | GAS 16
1192620 | Nivel 3 | GAS 16
1192627 | Nivel 3 | GAS 16
1192631 | Nivel 3 | GAS 16
1192637 | Nivel 3 | GAS 11
1192641 | Nivel 3 | GAS 3
1192647 | Nivel 3 | GAS 16
1192651 | Nivel 3 | GAS 14
1192655 | Nivel 3 | GAS 14
1192659 | Nivel 3 | GAS 14
1192663 | Nivel 3 | GAS 11
1192667 | Nivel 3 | GAS 3
1192671 | Nivel 3 | GAS 16
1192675 | Nivel 3 | GAS 14
1192711 | Nivel 4 | GAS 7
1192713 | Nivel 4 | GAS 7
1192725 | Nivel 4 | GAS 7
1192733 | Nivel 4 | GAS 7
1192737 | Nivel 4 | GAS 7
1192741 | Nivel 4 | GAS 7
1192745 | Nivel 4 | GAS 7
1192747 | Nivel 4 | GAS 7
1192758 | Nivel 4 | GAS 7
1192760 | Nivel 4 | GAS 7
1192762 | Nivel 4 | GAS 7
1192764 | Nivel 4 | GAS 7
1192771 | Nivel 4 | GAS 7
1192775 | Nivel 4 | GAS 7
1192783 | Nivel 4 | GAS 15
1192785 | Nivel 4 | GAS 15
1192797 | Nivel 4 | GAS 15
1192805 | Nivel 4 | GAS 15
1192809 | Nivel 4 | GAS 15
1192813 | Nivel 4 | GAS 15
1192817 | Nivel 4 | GAS 15
1192819 | Nivel 4 | GAS 15
1192830 | Nivel 4 | GAS 15
1192832 | Nivel 4 | GAS 15
1192834 | Nivel 4 | GAS 15
1192836 | Nivel 4 | GAS 15
1192843 | Nivel 4 | GAS 15
1192847 | Nivel 4 | GAS 15
1192855 | Nivel 4 | GAS 18
1192857 | Nivel 4 | GAS 18
1192869 | Nivel 4 | GAS 18
1192877 | Nivel 4 | GAS 18
1192881 | Nivel 4 | GAS 18
1192885 | Nivel 4 | GAS 18
1192889 | Nivel 4 | GAS 18
1192891 | Nivel 4 | GAS 18
1192902 | Nivel 4 | GAS 18
1192904 | Nivel 4 | GAS 18
1192906 | Nivel 4 | GAS 18
1192908 | Nivel 4 | GAS 18
1192915 | Nivel 4 | GAS 18
1192919 | Nivel 4 | GAS 18
1192925 | Nivel 4 | GAS 20
1192927 | Nivel 4 | GAS 20
1192939 | Nivel 4 | GAS 20
1192947 | Nivel 4 | GAS 20
1192951 | Nivel 4 | GAS 20
1192955 | Nivel 4 | GAS 20
1192959 | Nivel 4 | GAS 20
1192961 | Nivel 4 | GAS 20
1192972 | Nivel 4 | GAS 20
1192974 | Nivel 4 | GAS 20
1192976 | Nivel 4 | GAS 20
1192978 | Nivel 4 | GAS 20
1192985 | Nivel 4 | GAS 20
1192989 | Nivel 4 | GAS 20
1192995 | Nivel 4 | GAS 15
1192999 | Nivel 4 | GAS 7
1193005 | Nivel 4 | GAS 20
1193009 | Nivel 4 | GAS 18
1193013 | Nivel 4 | GAS 18
1193017 | Nivel 4 | GAS 18
1193021 | Nivel 4 | GAS 15
1193025 | Nivel 4 | GAS 7
1193029 | Nivel 4 | GAS 20
1193033 | Nivel 4 | GAS 18
1193069 | Nivel 5 | GAS 13
1193071 | Nivel 5 | GAS 13
1193083 | Nivel 5 | GAS 13
1193091 | Nivel 5 | GAS 13
1193095 | Nivel 5 | GAS 13
1193099 | Nivel 5 | GAS 13
1193103 | Nivel 5 | GAS 13
1193105 | Nivel 5 | GAS 13
1193116 | Nivel 5 | GAS 13
1193118 | Nivel 5 | GAS 13
1193120 | Nivel 5 | GAS 13
1193122 | Nivel 5 | GAS 13
1193129 | Nivel 5 | GAS 13
1193133 | Nivel 5 | GAS 13
1193141 | Nivel 5 | GAS 19
1193143 | Nivel 5 | GAS 19
1193155 | Nivel 5 | GAS 19
1193163 | Nivel 5 | GAS 19
1193167 | Nivel 5 | GAS 19
1193171 | Nivel 5 | GAS 19
1193175 | Nivel 5 | GAS 19
1193177 | Nivel 5 | GAS 19
1193188 | Nivel 5 | GAS 19
1193190 | Nivel 5 | GAS 19
1193192 | Nivel 5 | GAS 19
1193194 | Nivel 5 | GAS 19
1193201 | Nivel 5 | GAS 19
1193205 | Nivel 5 | GAS 19
1193213 | Nivel 5 | GAS 22
1193215 | Nivel 5 | GAS 22
1193227 | Nivel 5 | GAS 22
1193235 | Nivel 5 | GAS 22
1193239 | Nivel 5 | GAS 22
1193243 | Nivel 5 | GAS 22
1193247 | Nivel 5 | GAS 22
1193249 | Nivel 5 | GAS 22
1193260 | Nivel 5 | GAS 22
1193262 | Nivel 5 | GAS 22
1193264 | Nivel 5 | GAS 22
1193266 | Nivel 5 | GAS 22
1193273 | Nivel 5 | GAS 22
1193277 | Nivel 5 | GAS 22
1193283 | Nivel 5 | GAS 24
1193285 | Nivel 5 | GAS 24
1193297 | Nivel 5 | GAS 24
1193305 | Nivel 5 | GAS 24
1193309 | Nivel 5 | GAS 24
1193313 | Nivel 5 | GAS 24
1193317 | Nivel 5 | GAS 24
1193319 | Nivel 5 | GAS 24
1193330 | Nivel 5 | GAS 24
1193332 | Nivel 5 | GAS 24
1193334 | Nivel 5 | GAS 24
1193336 | Nivel 5 | GAS 24
1193343 | Nivel 5 | GAS 24
1193347 | Nivel 5 | GAS 24
1193353 | Nivel 5 | GAS 19
1193357 | Nivel 5 | GAS 13
1193363 | Nivel 5 | GAS 24
1193367 | Nivel 5 | GAS 22
1193371 | Nivel 5 | GAS 22
1193375 | Nivel 5 | GAS 22
1193379 | Nivel 5 | GAS 19
1193383 | Nivel 5 | GAS 13
1193387 | Nivel 5 | GAS 24
1193391 | Nivel 5 | GAS 22
1193427 | Nivel 6 | GAS 17
1193429 | Nivel 6 | GAS 17
1193441 | Nivel 6 | GAS 17
1193449 | Nivel 6 | GAS 17
1193453 | Nivel 6 | GAS 17
1193457 | Nivel 6 | GAS 17
1193461 | Nivel 6 | GAS 17
1193463 | Nivel 6 | GAS 17
1193474 | Nivel 6 | GAS 17
1193476 | Nivel 6 | GAS 17
1193478 | Nivel 6 | GAS 17
1193480 | Nivel 6 | GAS 17
1193487 | Nivel 6 | GAS 17
1193491 | Nivel 6 | GAS 17
1193499 | Nivel 6 | GAS 23
1193501 | Nivel 6 | GAS 23
1193513 | Nivel 6 | GAS 23
1193521 | Nivel 6 | GAS 23
1193525 | Nivel 6 | GAS 23
1193529 | Nivel 6 | GAS 23
1193533 | Nivel 6 | GAS 23
1193535 | Nivel 6 | GAS 23
1193546 | Nivel 6 | GAS 23
1193548 | Nivel 6 | GAS 23
1193550 | Nivel 6 | GAS 23
1193552 | Nivel 6 | GAS 23
1193559 | Nivel 6 | GAS 23
1193563 | Nivel 6 | GAS 23
1193571 | Nivel 6 | GAS 26
1193573 | Nivel 6 | GAS 26
1193585 | Nivel 6 | GAS 26
1193593 | Nivel 6 | GAS 26
1193597 | Nivel 6 | GAS 26
1193601 | Nivel 6 | GAS 26
1193605 | Nivel 6 | GAS 26
1193607 | Nivel 6 | GAS 26
1193618 | Nivel 6 | GAS 26
1193620 | Nivel 6 | GAS 26
1193622 | Nivel 6 | GAS 26
1193624 | Nivel 6 | GAS 26
1193631 | Nivel 6 | GAS 26
1193635 | Nivel 6 | GAS 26
1193641 | Nivel 6 | GAS 28
1193643 | Nivel 6 | GAS 28
1193655 | Nivel 6 | GAS 28
1193663 | Nivel 6 | GAS 28
1193667 | Nivel 6 | GAS 28
1193671 | Nivel 6 | GAS 28
1193675 | Nivel 6 | GAS 28
1193677 | Nivel 6 | GAS 28
1193688 | Nivel 6 | GAS 28
1193690 | Nivel 6 | GAS 28
1193692 | Nivel 6 | GAS 28
1193694 | Nivel 6 | GAS 28
1193701 | Nivel 6 | GAS 28
1193705 | Nivel 6 | GAS 28
1193711 | Nivel 6 | GAS 23
1193715 | Nivel 6 | GAS 17
1193721 | Nivel 6 | GAS 28
1193725 | Nivel 6 | GAS 26
1193729 | Nivel 6 | GAS 26
1193733 | Nivel 6 | GAS 26
1193737 | Nivel 6 | GAS 23
1193741 | Nivel 6 | GAS 17
1193745 | Nivel 6 | GAS 28
1193749 | Nivel 6 | GAS 26
1330725 | Nivel 1 | GAS 2
1330729 | Nivel 1 | GAS 2
1330732 | Nivel 1 | GAS 2
1330734 | Nivel 1 | GAS 2
1330747 | Nivel 1 | GAS 2
1330752 | Nivel 1 | GAS 2
1330754 | Nivel 1 | GAS 2

# IfcPipeFitting: D2060 - Reduccion roscada:Standard (7)
Type - Material: <Unnamed>
Classification: 21.04.20.60.30 Uniformat (Uniformat); Group: GAS 2
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2060 - Reduccion roscada:Standard:...) | In | Length (m)
1060617 | Nivel 1 | 0.0434221
1060789 | Nivel 2 | 0.0434221
1060952 | Nivel 5 | 0.0374531
1060954 | Nivel 5 | 0.0374531
1060960 | Nivel 4 | 0.0374531
1306591 | Nivel 2 | 0.0434221
1306593 | Nivel 3 | 0.0374531

# IfcPipeFitting: D2060 - Tapa roscada:Standard (24)
Type - Material: <Unnamed>
Classification: 21.04.20.60.30 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2060 - Tapa roscada:Standard:...) | In | Group
1105094 | Nivel 1 | GAS 5
1118251 | Nivel 1 | GAS 6
1118327 | Nivel 1 | GAS 8
1118403 | Nivel 1 | GAS 9
1192061 | Nivel 2 | GAS 1
