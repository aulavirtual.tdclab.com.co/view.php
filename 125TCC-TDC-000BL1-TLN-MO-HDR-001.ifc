Properties of the parts of a building model (IFC4), part 20 of 21

# IfcPipeSegment: Pipe Types:D2020-PVC.S (1027)
Name (Pipe Types:D2020-PVC.S:...) | In | InvertElevation (m) | Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Group
1098384 | Nivel 5 | 9.41416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1098388 | Nivel 5 | 9.4122 | 0.361245 | 0.00285724 | 0.0684562 | AR-DOM 1
1098392 | Nivel 5 | 9.23095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1098394 | Nivel 5 | 9.23019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1098400 | Nivel 5 | 9.22304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1098406 | Nivel 5 | 9.2201 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1098408 | Nivel 5 | 9.22195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1098411 | Nivel 5 | 9.22231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1098414 | Nivel 5 | 9.22366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1098416 | Nivel 5 | 9.22924 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1098419 | Nivel 5 | 9.22924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1098422 | Nivel 5 | 9.22948 | 0.0483453 | 0.00285724 | 0.00916148 | AR-DOM 1
1098424 | Nivel 5 | 9.22941 | 0.200589 | 0.0102593 | 0.0720282 | AR-DOM 1
1098428 | Nivel 5 | 9.07722 | 0.186142 | 0.0102593 | 0.0668407 | AR-DOM 1
1098432 | Nivel 5 | 9.99498 | 0.916438 | 0.0102593 | 0.329078 | AR-DOM 1
1098438 | Nivel 5 | 9.40534 | 1.28051 | 0.00285724 | 0.242658 | AR-DOM 1
1098446 | Nivel 5 | 8.77681 | 0.609488 | 0.00285724 | 0.115498 | AR-DOM 1
1098450 | Nivel 5 | 8.96437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1098452 | Nivel 5 | 8.79076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1098456 | Nivel 5 | 9.8832 | 0.348823 | 0.00285724 | 0.0661023 | AR-DOM 1
1098461 | Nivel 5 | 9.62664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1098464 | Nivel 5 | 9.88626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1098471 | Nivel 5 | 9.27177 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1098474 | Nivel 5 | 9.54949 | 0.00972585 | 0.00285724 | 0.00184306 | AR-DOM 1; VENT 6
1098480 | Nivel 5 | 9.22195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1098482 | Nivel 5 | 9.22362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1098490 | Nivel 5 | 9.30598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1098492 | Nivel 5 | 9.87276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1098498 | Nivel 5 | 8.8899 | 0.0273266 | 0.00285724 | 0.00517841 | AR-DOM 1
1098501 | Nivel 5 | 9.00168 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1098504 | Nivel 5 | 8.89021 | 0.161114 | 0.00285724 | 0.0305313 | AR-DOM 1
1098514 | Nivel 5 | 9.23109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1098516 | Nivel 4 | 9.49432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1098520 | Nivel 4 | 9.97234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1098526 | Nivel 5 | 9.3121 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1098530 | Nivel 5 | 9.38653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1098536 | Nivel 5 | 10.1761 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1098538 | Nivel 5 | 10.1164 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1098544 | Nivel 5 | 7.64498 | 0.916438 | 0.0102593 | 0.329078 | AR-DOM 1
1098546 | Nivel 5 | 11.7698 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1098548 | Nivel 5 | 11.7691 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1098552 | Nivel 5 | 11.7648 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1098556 | Nivel 6 | 11.7642 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1098560 | Nivel 6 | 11.7622 | 0.361245 | 0.00285724 | 0.0684562 | AR-DOM 1
1098564 | Nivel 6 | 11.581 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1098566 | Nivel 6 | 11.5802 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1098572 | Nivel 6 | 11.573 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1098578 | Nivel 6 | 11.5701 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1098580 | Nivel 6 | 11.572 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1098583 | Nivel 6 | 11.5723 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1098586 | Nivel 6 | 11.5737 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1098588 | Nivel 6 | 11.5792 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1098591 | Nivel 6 | 11.5792 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1098594 | Nivel 6 | 11.5795 | 0.0483453 | 0.00285724 | 0.00916148 | AR-DOM 1
1098596 | Nivel 6 | 11.5794 | 0.200589 | 0.0102593 | 0.0720282 | AR-DOM 1
1098600 | Nivel 6 | 11.4272 | 0.186142 | 0.0102593 | 0.0668407 | AR-DOM 1
1098608 | Nivel 6 | 11.7553 | 1.28051 | 0.00285724 | 0.242658 | AR-DOM 1
1098616 | Nivel 6 | 11.1268 | 0.609488 | 0.00285724 | 0.115498 | AR-DOM 1
1098620 | Nivel 6 | 11.3144 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1098622 | Nivel 6 | 11.1408 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1098626 | Nivel 6 | 12.2332 | 0.348823 | 0.00285724 | 0.0661023 | AR-DOM 1
1098631 | Nivel 6 | 11.9766 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1098634 | Nivel 6 | 12.2363 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1098639 | Nivel 6 | 11.6218 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1098642 | Nivel 6 | 11.8995 | 0.00972585 | 0.00285724 | 0.00184306 | AR-DOM 1; VENT 6
1098648 | Nivel 6 | 11.5719 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1098650 | Nivel 6 | 11.5736 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1098658 | Nivel 6 | 11.656 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1098660 | Nivel 6 | 12.2228 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1098666 | Nivel 6 | 11.2399 | 0.0273266 | 0.00285724 | 0.00517841 | AR-DOM 1
1098669 | Nivel 6 | 11.3517 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1098672 | Nivel 6 | 11.2402 | 0.161114 | 0.00285724 | 0.0305313 | AR-DOM 1
1098682 | Nivel 6 | 11.5811 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1098684 | Nivel 5 | 11.8443 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1098688 | Nivel 5 | 12.3223 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1098694 | Nivel 6 | 11.6621 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1098698 | Nivel 6 | 11.7365 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1098704 | Nivel 6 | 12.5261 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1098706 | Nivel 6 | 12.4664 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1098712 | Nivel 6 | 12.345 | 0.375596 | 0.0102593 | 0.13487 | AR-DOM 1; VENT 6
1106842 | Nivel 1 | -0.673448 | 0.260542 | 0.0102593 | 0.0935564 | AR-DOM 4
1106887 | Nivel 1 | -0.644433 | 0.0738908 | 0.00285724 | 0.0140024 | AR-DOM 4
1106900 | Nivel 1 | -0.67099 | 0.679898 | 0.0102593 | 0.24414 | AR-DOM 4
1106934 | Nivel 1 | -0.642798 | 0.672798 | 0.00285724 | 0.127496 | AR-DOM 4
1107003 | Nivel 1 | -0.670941 | 0.146312 | 0.0102593 | 0.0525383 | AR-DOM 4
1107045 | Nivel 1 | -0.642494 | 0.0660213 | 0.00285724 | 0.0125111 | AR-DOM 4
1107054 | Nivel 1 | -0.669047 | 0.669253 | 0.0102593 | 0.240318 | AR-DOM 4
1107074 | Nivel 1 | -0.640899 | 0.670899 | 0.00285724 | 0.127136 | AR-DOM 4
1223689 | Nivel 6 | 12.345 | 0.123254 | 0.0102593 | 0.0442584 | AR-DOM 1
1223770 | Nivel 6 | 12.345 | 0.123268 | 0.0102593 | 0.0442637 | AR-DOM 1
1223859 | Nivel 5 | 8.09261 | 0.468813 | 0.0102593 | 0.168343 | AR-DOM 1
1224032 | Nivel 5 | 8.09261 | 0.468813 | 0.0102593 | 0.168343 | AR-DOM 1
1244584 | Nivel 1 | -0.818299 | 0.0618358 | 0.0102593 | 0.0222042 | AR-DOM 1
1244610 | Nivel 1 | -0.817627 | 0.116883 | 0.0102593 | 0.0419708 | AR-DOM 1
1246853 | Nivel 1 | -0.625892 | 0.152448 | 0.00285724 | 0.0288891 | AR-DOM 4
1246862 | Nivel 1 | -0.627504 | 0.14759 | 0.00285724 | 0.0279685 | AR-DOM 4
1246995 | Nivel 1 | -0.644559 | 0.162355 | 0.00285724 | 0.0307663 | AR-DOM 4
1247008 | Nivel 1 | -0.646087 | 0.129231 | 0.00285724 | 0.0244893 | AR-DOM 4
1247092 | Nivel 1 | -0.642482 | 0.672482 | 0.00285724 | 0.127436 | AR-DOM 4
1247109 | Nivel 1 | -0.64406 | 0.67406 | 0.00285724 | 0.127735 | AR-DOM 4
1247124 | Nivel 1 | -0.625582 | 0.655582 | 0.00285724 | 0.124233 | AR-DOM 4
1247207 | Nivel 1 | -0.645889 | 0.112805 | 0.00285724 | 0.0213766 | AR-DOM 4
1247216 | Nivel 1 | -0.648304 | 0.307956 | 0.00285724 | 0.0583579 | AR-DOM 4
1247345 | Nivel 1 | -0.627624 | 0.155394 | 0.00285724 | 0.0294473 | AR-DOM 4
1247354 | Nivel 1 | -0.629711 | 0.243899 | 0.00285724 | 0.046219 | AR-DOM 4
1248231 | Nivel 1 | -0.645574 | 0.476522 | 0.00285724 | 0.0903014 | AR-DOM 4
1248791 | Nivel 1 | -0.0769565 | 0.628879 | 0.00285724 | 0.119173 | AR-DOM 4
1248793 | Nivel 1 | 0.570732 | 0.0389407 | 0.00285724 | 0.0073793 | AR-DOM 4
1248799 | Nivel 1 | -0.150246 | 0.214171 | 0.00285724 | 0.0405856 | AR-DOM 4
1248803 | Nivel 1 | -0.647791 | 0.478739 | 0.00285724 | 0.0907215 | AR-DOM 4
1248814 | Nivel 1 | -0.077006 | 0.628928 | 0.00285724 | 0.119182 | AR-DOM 4
1248816 | Nivel 1 | 0.570732 | 0.0389407 | 0.00285724 | 0.0073793 | AR-DOM 4
1248822 | Nivel 1 | -0.150295 | 0.209016 | 0.00285724 | 0.0396086 | AR-DOM 4
1248826 | Nivel 1 | -0.629198 | 0.460095 | 0.00285724 | 0.0871885 | AR-DOM 4
1248835 | Nivel 1 | -0.0770061 | 0.628928 | 0.00285724 | 0.119182 | AR-DOM 4
1248837 | Nivel 1 | 0.570732 | 0.0389407 | 0.00285724 | 0.0073793 | AR-DOM 4
1248843 | Nivel 1 | -0.150295 | 0.211086 | 0.00285724 | 0.0400009 | AR-DOM 4
1248847 | Nivel 1 | -0.62699 | 0.457888 | 0.00285724 | 0.0867702 | AR-DOM 4

# IfcPipeSegment: Pipe Types:D2020-PVC.V (56)
Type - PredefinedType: RIGIDSEGMENT
Classification: 21.04.20.20.30 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: D2020-PVC.V; sets with these values: 2
Name (Pipe Types:D2020-PVC.V:...) | In | InvertElevation (m) | Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Group
953481 | Nivel 2 | 2.6669 | 2.17527 | 0.00285724 | 0.412216 | VENT 1
1063660 | Nivel 2 | -0.561141 | 3.05332 | 0.00285724 | 0.578606 | VENT 2
1081263 | Nivel 2 | -0.567761 | 3.05994 | 0.00285724 | 0.57986 | VENT 3
1081271 | Nivel 2 | -0.644983 | 0.51243 | 0.00285724 | 0.0971059 | VENT 3
1081581 | Nivel 1 | -0.634213 | 0.136283 | 0.00285724 | 0.0258258 | VENT 6
1081627 | Nivel 1 | -0.634149 | 0.474483 | 0.00285724 | 0.089915 | VENT 6
1081855 | Nivel 2 | -0.634149 | 0.278691 | 0.00285724 | 0.0528123 | VENT 6
1082072 | Nivel 1 | -0.635683 | 0.217472 | 0.00285724 | 0.0412111 | VENT 2
1082098 | Nivel 1 | -0.635571 | 0.490461 | 0.00285724 | 0.0929428 | VENT 2
1082108 | Nivel 1 | -0.635571 | 0.268709 | 0.00285724 | 0.0509206 | VENT 2
1082715 | Nivel 1 | -0.647417 | 0.530248 | 0.00285724 | 0.100482 | VENT 1
1091397 | Nivel 2 | -0.572987 | 3.06516 | 0.00285724 | 0.580851 | VENT 1
1092065 | Nivel 3 | 5.0169 | 2.17527 | 0.00285724 | 0.412216 | VENT 1
1092474 | Nivel 4 | 7.3669 | 2.17527 | 0.00285724 | 0.412216 | VENT 1
1092882 | Nivel 5 | 9.7169 | 2.17527 | 0.00285724 | 0.412216 | VENT 1
1093855 | Nivel 6 | 12.0669 | 0.59908 | 0.00285724 | 0.113526 | VENT 1
1093863 | Nivel 6 | 12.6784 | 0.109418 | 0.00285724 | 0.0207349 | VENT 1
1093978 | Nivel 6 | 14.8337 | 0.096118 | 0.0102593 | 0.0345144 | VENT 1
1093989 | Nivel 6 | 14.7187 | 0.07335 | 0.0102593 | 0.0263388 | VENT 1
1095344 | Nivel 2 | 2.6669 | 2.17527 | 0.00285724 | 0.412216 | VENT 2
1095518 | Nivel 3 | 5.0169 | 2.17527 | 0.00285724 | 0.412216 | VENT 2
1095686 | Nivel 4 | 7.3669 | 2.17527 | 0.00285724 | 0.412216 | VENT 2
1095856 | Nivel 5 | 9.7169 | 2.17527 | 0.00285724 | 0.412216 | VENT 2
1096102 | Nivel 6 | 12.0669 | 0.598774 | 0.00285724 | 0.113468 | VENT 2
1096104 | Nivel 6 | 12.6781 | 0.109701 | 0.00285724 | 0.0207885 | VENT 2
1096112 | Nivel 6 | 14.8387 | 0.103133 | 0.0102593 | 0.0370336 | VENT 2
1096116 | Nivel 6 | 14.7337 | 0.06335 | 0.0102593 | 0.022748 | VENT 2
1097086 | Nivel 2 | 2.6669 | 2.17527 | 0.00285724 | 0.412216 | VENT 3
1097260 | Nivel 3 | 5.0169 | 2.17527 | 0.00285724 | 0.412216 | VENT 3
1097428 | Nivel 4 | 7.3669 | 2.17527 | 0.00285724 | 0.412216 | VENT 3
1097598 | Nivel 5 | 9.7169 | 2.17527 | 0.00285724 | 0.412216 | VENT 3
1097844 | Nivel 6 | 12.066 | 0.576255 | 0.00285724 | 0.109201 | VENT 3
1097846 | Nivel 6 | 12.6572 | 0.29911 | 0.00285724 | 0.0566817 | VENT 3
1097854 | Nivel 6 | 14.8337 | 0.100403 | 0.0102593 | 0.0360529 | VENT 3
1097858 | Nivel 6 | 14.7287 | 0.06335 | 0.0102593 | 0.022748 | VENT 3
1097956 | Nivel 2 | 2.66588 | 2.17532 | 0.00285724 | 0.412225 | VENT 6
1098034 | Nivel 2 | -0.559719 | 3.05087 | 0.00285724 | 0.578142 | VENT 6
1098130 | Nivel 3 | 5.01593 | 2.17527 | 0.00285724 | 0.412216 | VENT 6
1098298 | Nivel 4 | 7.36593 | 2.17527 | 0.00285724 | 0.412216 | VENT 6
1098468 | Nivel 5 | 9.71593 | 2.17527 | 0.00285724 | 0.412216 | VENT 6
1098714 | Nivel 6 | 12.0659 | 0.601316 | 0.00285724 | 0.11395 | VENT 6
1098716 | Nivel 6 | 12.6794 | 0.107911 | 0.00285724 | 0.0204492 | VENT 6
1098722 | Nivel 6 | 13.8759 | 0.921209 | 0.0102593 | 0.330791 | VENT 6
1098724 | Nivel 6 | 14.8387 | 0.0984344 | 0.0102593 | 0.0353462 | VENT 6
1098728 | Nivel 6 | 14.7337 | 0.06335 | 0.0102593 | 0.022748 | VENT 6
1344840 | Nivel 6 | 12.9499 | 0.732649 | 0.0102593 | 0.263082 | VENT 1
1344856 | Nivel 6 | 12.9499 | 0.717649 | 0.0102593 | 0.257696 | VENT 2
1345173 | Nivel 6 | 13.0028 | 0.759764 | 0.0102593 | 0.272819 | VENT 3
1345196 | Nivel 6 | 13.9559 | 0.836235 | 0.0102593 | 0.300279 | VENT 3
1345343 | Nivel 6 | 13.8758 | 0.916247 | 0.0102593 | 0.32901 | VENT 1
1345549 | Nivel 6 | 12.9499 | 0.732629 | 0.0102593 | 0.263075 | VENT 6
1345606 | Nivel 6 | 13.7242 | 0.0943426 | 0.0102593 | 0.0338769 | VENT 6
1345732 | Nivel 6 | 13.8608 | 0.936243 | 0.0102593 | 0.33619 | VENT 2
1345981 | Nivel 7 | 13.7242 | 0.0945371 | 0.0102593 | 0.0339467 | VENT 1
1346101 | Nivel 7 | 13.7092 | 0.0997202 | 0.0102593 | 0.0358079 | VENT 2
1346234 | Nivel 7 | 13.8042 | 0.0940914 | 0.0102593 | 0.0337867 | VENT 3

# IfcPipeSegment: Pipe Types:D2060-AG.SCH40 (542)
Type - PredefinedType: RIGIDSEGMENT
Classification: 21.04.30.10.10 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: D2060-AG.SCH40; sets with these values: 2
Name (Pipe Types:D2060-AG.SCH40:...) | In | InvertElevation (m) | Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Group
1054979 | Nivel 1 | -0.213977 | 8.80674 | 0.000876079 | 0.924112 | GAS 2
1054993 | Nivel 1 | -0.211497 | 1.63652 | 0.000876079 | 0.171724 | GAS 2
1060498 | Nivel 1 | 0.154979 | 0.746677 | 0.000357613 | 0.0500584 | GAS 2
1060540 | Nivel 1 | 9.63216 | 2.25385 | 0.000357613 | 0.151102 | GAS 2
1060590 | Nivel 1 | -0.161396 | 0.287496 | 0.000876079 | 0.0301677 | GAS 2
1060596 | Nivel 1 | 0.189751 | 0.0227489 | 0.000357613 | 0.00152513 | GAS 2
1060681 | Nivel 2 | 2.50498 | 0.746677 | 0.000357613 | 0.0500584 | GAS 2
1060683 | Nivel 2 | 2.53975 | 0.0231276 | 0.000357613 | 0.00155051 | GAS 2
1060696 | Nivel 3 | 4.85498 | 0.757599 | 0.000357613 | 0.0507906 | GAS 2
1060698 | Nivel 3 | 4.88975 | 0.0231276 | 0.000357613 | 0.00155051 | GAS 2
1060711 | Nivel 4 | 7.20498 | 0.757599 | 0.000357613 | 0.0507906 | GAS 2
1060713 | Nivel 4 | 7.23975 | 0.0231276 | 0.000357613 | 0.00155051 | GAS 2
1060726 | Nivel 5 | 9.55498 | 0.757599 | 0.000357613 | 0.0507906 | GAS 2
1060728 | Nivel 5 | 9.58975 | 0.0231276 | 0.000357613 | 0.00155051 | GAS 2
1060741 | Nivel 6 | 11.905 | 0.800005 | 0.000357613 | 0.0536336 | GAS 2
1060743 | Nivel 6 | 11.9398 | 0.0231276 | 0.000357613 | 0.00155051 | GAS 2
1060782 | Nivel 1 | 0.199657 | 2.27644 | 0.000876079 | 0.238873 | GAS 2
1060818 | Nivel 1 | 2.59308 | 2.23797 | 0.000558561 | 0.187512 | GAS 2
1060854 | Nivel 1 | 4.8947 | 2.28635 | 0.000558561 | 0.191565 | GAS 2
1060890 | Nivel 1 | 7.2447 | 2.28635 | 0.000558561 | 0.191565 | GAS 2
1062683 | Nivel 1 | -0.542638 | 1.00623 | 0.000876079 | 0.105586 | GAS 2
1062693 | Nivel 1 | 0.487049 | 0.0916539 | 0.000876079 | 0.00961745 | GAS 2
1062818 | Nivel 1 | -0.592741 | 0.0491949 | 0.000876079 | 0.00516214 | GAS 2
1105024 | Nivel 1 | -0.0197745 | 0.851254 | 0.000357613 | 0.0570694 | GAS 5
1105026 | Nivel 1 | -0.0197745 | 0.583755 | 0.000357613 | 0.0391359 | GAS 5
1105032 | Nivel 1 | -0.0197745 | 0.396255 | 0.000357613 | 0.0265656 | GAS 5
1105034 | Nivel 1 | -0.0197745 | 0.116255 | 0.000357613 | 0.00779393 | GAS 5
1105036 | Nivel 1 | 0.292101 | 0.100378 | 0.000357613 | 0.00672947 | GAS 5
1105038 | Nivel 1 | -0.0197745 | 2.15126 | 0.000357613 | 0.144224 | GAS 5
1105040 | Nivel 1 | -0.0197745 | 0.808869 | 0.000357613 | 0.0542279 | GAS 5
1105046 | Nivel 1 | -0.0197745 | 2.82126 | 0.000357613 | 0.189141 | GAS 5
1105048 | Nivel 1 | -0.0197745 | 0.776255 | 0.000357613 | 0.0520414 | GAS 5
1105052 | Nivel 1 | -0.0197745 | 0.419323 | 0.000357613 | 0.0281121 | GAS 5
1105056 | Nivel 1 | 0.0149974 | 0.95813 | 0.000357613 | 0.0642346 | GAS 5
1105060 | Nivel 1 | 0.992101 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 5
1105066 | Nivel 1 | 1.1315 | 0.0685 | 0.000357613 | 0.00459235 | GAS 5
1105069 | Nivel 1 | 1.02687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 5
1105071 | Nivel 1 | 0.0149974 | 0.25813 | 0.000357613 | 0.0173055 | GAS 5
1105073 | Nivel 1 | 0.0149974 | 0.25813 | 0.000357613 | 0.0173055 | GAS 5
1105084 | Nivel 1 | 0.292101 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 5
1105086 | Nivel 1 | 0.0149974 | 0.446255 | 0.000357613 | 0.0299177 | GAS 5
1105090 | Nivel 1 | 0.480226 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 5
1118181 | Nivel 1 | -0.0197745 | 0.756255 | 0.000357613 | 0.0507005 | GAS 6
1118183 | Nivel 1 | -0.0197745 | 0.583755 | 0.000357613 | 0.0391359 | GAS 6
1118189 | Nivel 1 | -0.0197745 | 0.396255 | 0.000357613 | 0.0265656 | GAS 6
1118191 | Nivel 1 | -0.0197745 | 0.116255 | 0.000357613 | 0.00779393 | GAS 6
1118193 | Nivel 1 | 0.292101 | 0.100378 | 0.000357613 | 0.00672947 | GAS 6
1118195 | Nivel 1 | -0.0197745 | 2.15126 | 0.000357613 | 0.144224 | GAS 6
1118197 | Nivel 1 | -0.0197745 | 0.808869 | 0.000357613 | 0.0542279 | GAS 6
1118203 | Nivel 1 | -0.0197745 | 2.82126 | 0.000357613 | 0.189141 | GAS 6
1118205 | Nivel 1 | -0.0197745 | 0.776255 | 0.000357613 | 0.0520414 | GAS 6
1118209 | Nivel 1 | -0.0197745 | 0.419323 | 0.000357613 | 0.0281121 | GAS 6
1118213 | Nivel 1 | 0.0149974 | 0.95813 | 0.000357613 | 0.0642346 | GAS 6
1118217 | Nivel 1 | 0.992101 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 6
1118223 | Nivel 1 | 1.1315 | 0.0685 | 0.000357613 | 0.00459235 | GAS 6
1118226 | Nivel 1 | 1.02687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 6
1118228 | Nivel 1 | 0.0149974 | 0.25813 | 0.000357613 | 0.0173055 | GAS 6
1118230 | Nivel 1 | 0.0149974 | 0.25813 | 0.000357613 | 0.0173055 | GAS 6
1118241 | Nivel 1 | 0.292101 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 6
1118243 | Nivel 1 | 0.0149974 | 0.446255 | 0.000357613 | 0.0299177 | GAS 6
1118247 | Nivel 1 | 0.480226 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 6
1118257 | Nivel 1 | -0.0197745 | 1.04626 | 0.000357613 | 0.0701426 | GAS 8
1118259 | Nivel 1 | -0.0197745 | 0.583755 | 0.000357613 | 0.0391359 | GAS 8
1118265 | Nivel 1 | -0.0197745 | 0.396255 | 0.000357613 | 0.0265656 | GAS 8
1118267 | Nivel 1 | -0.0197745 | 0.116255 | 0.000357613 | 0.00779393 | GAS 8
1118269 | Nivel 1 | 0.292101 | 0.100378 | 0.000357613 | 0.00672947 | GAS 8
1118271 | Nivel 1 | -0.0197745 | 2.15126 | 0.000357613 | 0.144224 | GAS 8
1118273 | Nivel 1 | -0.0197745 | 0.808869 | 0.000357613 | 0.0542279 | GAS 8
1118279 | Nivel 1 | -0.0197745 | 2.74861 | 0.000357613 | 0.184271 | GAS 8
1118281 | Nivel 1 | -0.0197745 | 0.776255 | 0.000357613 | 0.0520414 | GAS 8
1118285 | Nivel 1 | -0.0197745 | 0.346681 | 0.000357613 | 0.023242 | GAS 8
1118289 | Nivel 1 | 0.0149974 | 0.95813 | 0.000357613 | 0.0642346 | GAS 8
1118293 | Nivel 1 | 0.992101 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 8
1118299 | Nivel 1 | 1.1315 | 0.0685 | 0.000357613 | 0.00459235 | GAS 8
1118302 | Nivel 1 | 1.02687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 8
1118304 | Nivel 1 | 0.0149974 | 0.25813 | 0.000357613 | 0.0173055 | GAS 8
1118306 | Nivel 1 | 0.0149974 | 0.25813 | 0.000357613 | 0.0173055 | GAS 8
1118317 | Nivel 1 | 0.292101 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 8
1118319 | Nivel 1 | 0.0149974 | 0.446255 | 0.000357613 | 0.0299177 | GAS 8
1118323 | Nivel 1 | 0.480226 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 8
1118335 | Nivel 1 | -0.0197745 | 0.583755 | 0.000357613 | 0.0391359 | GAS 9
1118341 | Nivel 1 | -0.0197745 | 0.396255 | 0.000357613 | 0.0265656 | GAS 9
1118343 | Nivel 1 | -0.0197745 | 0.116255 | 0.000357613 | 0.00779393 | GAS 9
1118345 | Nivel 1 | 0.292101 | 0.100378 | 0.000357613 | 0.00672947 | GAS 9
1118347 | Nivel 1 | -0.0197745 | 2.15126 | 0.000357613 | 0.144224 | GAS 9
1118349 | Nivel 1 | -0.0197745 | 0.808869 | 0.000357613 | 0.0542279 | GAS 9
1118355 | Nivel 1 | -0.0197745 | 2.82126 | 0.000357613 | 0.189141 | GAS 9
1118357 | Nivel 1 | -0.0197745 | 0.776255 | 0.000357613 | 0.0520414 | GAS 9
1118361 | Nivel 1 | -0.0197745 | 0.419323 | 0.000357613 | 0.0281121 | GAS 9
1118365 | Nivel 1 | 0.0149974 | 0.95813 | 0.000357613 | 0.0642346 | GAS 9
1118369 | Nivel 1 | 0.992101 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 9
1118375 | Nivel 1 | 1.1315 | 0.0685 | 0.000357613 | 0.00459235 | GAS 9
1118378 | Nivel 1 | 1.02687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 9
1118380 | Nivel 1 | 0.0149974 | 0.25813 | 0.000357613 | 0.0173055 | GAS 9
1118382 | Nivel 1 | 0.0149974 | 0.25813 | 0.000357613 | 0.0173055 | GAS 9
1118393 | Nivel 1 | 0.292101 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 9
1118395 | Nivel 1 | 0.0149974 | 0.446255 | 0.000357613 | 0.0299177 | GAS 9
1118399 | Nivel 1 | 0.480226 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 9
1118456 | Nivel 1 | -0.0198077 | 0.226255 | 0.000357613 | 0.0151685 | GAS 6
1118503 | Nivel 1 | -0.0197991 | 1.94626 | 0.000357613 | 0.13048 | GAS 5
1118576 | Nivel 1 | -0.0197994 | 4.66626 | 0.000357613 | 0.312833 | GAS 9
1118584 | Nivel 1 | -0.0197995 | 1.94626 | 0.000357613 | 0.13048 | GAS 9
1118612 | Nivel 1 | -0.0197991 | 1.58626 | 0.000357613 | 0.106345 | GAS 8
1118624 | Nivel 1 | -0.0197995 | 3.45878 | 0.000357613 | 0.231882 | GAS 8
1118634 | Nivel 1 | -0.0197995 | 1.86626 | 0.000357613 | 0.125117 | GAS 8
1118812 | Nivel 1 | 0.0149605 | 0.11504 | 0.000357613 | 0.00771243 | GAS 6
1118842 | Nivel 1 | 0.0149724 | 0.115028 | 0.000357613 | 0.00771163 | GAS 5
1118877 | Nivel 1 | 0.0149724 | 0.115028 | 0.000357613 | 0.00771163 | GAS 9
1118907 | Nivel 1 | 0.0149724 | 0.115028 | 0.000357613 | 0.00771163 | GAS 8
1191991 | Nivel 2 | 2.33023 | 0.851229 | 0.000357613 | 0.0570677 | GAS 1
1191993 | Nivel 2 | 2.33023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 1
1191999 | Nivel 2 | 2.33023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 1
1192001 | Nivel 2 | 2.33023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 1
1192003 | Nivel 2 | 2.6421 | 0.100378 | 0.000357613 | 0.00672947 | GAS 1
1192005 | Nivel 2 | 2.33023 | 2.15126 | 0.000357613 | 0.144224 | GAS 1
1192007 | Nivel 2 | 2.33023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 1
1192013 | Nivel 2 | 2.33023 | 2.82126 | 0.000357613 | 0.189141 | GAS 1
1192015 | Nivel 2 | 2.33023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 1
1192019 | Nivel 2 | 2.33023 | 0.419323 | 0.000357613 | 0.0281121 | GAS 1
1192023 | Nivel 2 | 2.365 | 0.95813 | 0.000357613 | 0.0642346 | GAS 1
1192027 | Nivel 2 | 3.3421 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 1
1192033 | Nivel 2 | 3.4815 | 0.0685 | 0.000357613 | 0.00459235 | GAS 1
1192036 | Nivel 2 | 3.37687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 1
1192038 | Nivel 2 | 2.365 | 0.25813 | 0.000357613 | 0.0173055 | GAS 1
1192040 | Nivel 2 | 2.365 | 0.25813 | 0.000357613 | 0.0173055 | GAS 1
1192051 | Nivel 2 | 2.6421 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 1
1192053 | Nivel 2 | 2.365 | 0.446255 | 0.000357613 | 0.0299177 | GAS 1
1192057 | Nivel 2 | 2.83023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 1
1192063 | Nivel 2 | 2.33022 | 0.756255 | 0.000357613 | 0.0507005 | GAS 4
1192065 | Nivel 2 | 2.33023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 4
1192071 | Nivel 2 | 2.33023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 4
1192073 | Nivel 2 | 2.33023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 4
1192075 | Nivel 2 | 2.6421 | 0.100378 | 0.000357613 | 0.00672947 | GAS 4
1192077 | Nivel 2 | 2.33023 | 2.15126 | 0.000357613 | 0.144224 | GAS 4
1192079 | Nivel 2 | 2.33023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 4
1192085 | Nivel 2 | 2.33023 | 2.82126 | 0.000357613 | 0.189141 | GAS 4
1192087 | Nivel 2 | 2.33023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 4
1192091 | Nivel 2 | 2.33023 | 0.419323 | 0.000357613 | 0.0281121 | GAS 4
1192095 | Nivel 2 | 2.365 | 0.95813 | 0.000357613 | 0.0642346 | GAS 4
1192099 | Nivel 2 | 3.3421 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 4
1192105 | Nivel 2 | 3.4815 | 0.0685 | 0.000357613 | 0.00459235 | GAS 4
1192108 | Nivel 2 | 3.37687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 4
1192110 | Nivel 2 | 2.365 | 0.25813 | 0.000357613 | 0.0173055 | GAS 4
1192112 | Nivel 2 | 2.365 | 0.25813 | 0.000357613 | 0.0173055 | GAS 4
1192123 | Nivel 2 | 2.6421 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 4
1192125 | Nivel 2 | 2.365 | 0.446255 | 0.000357613 | 0.0299177 | GAS 4
1192129 | Nivel 2 | 2.83023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 4
1192135 | Nivel 2 | 2.33023 | 1.04626 | 0.000357613 | 0.0701426 | GAS 10
1192137 | Nivel 2 | 2.33023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 10
1192143 | Nivel 2 | 2.33023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 10
1192145 | Nivel 2 | 2.33023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 10
1192147 | Nivel 2 | 2.6421 | 0.100378 | 0.000357613 | 0.00672947 | GAS 10
1192149 | Nivel 2 | 2.33023 | 2.15126 | 0.000357613 | 0.144224 | GAS 10
1192151 | Nivel 2 | 2.33023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 10
1192157 | Nivel 2 | 2.33023 | 2.72126 | 0.000357613 | 0.182437 | GAS 10
1192159 | Nivel 2 | 2.33023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 10
1192163 | Nivel 2 | 2.33023 | 0.319323 | 0.000357613 | 0.0214079 | GAS 10
1192167 | Nivel 2 | 2.365 | 0.95813 | 0.000357613 | 0.0642346 | GAS 10
1192171 | Nivel 2 | 3.3421 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 10
1192177 | Nivel 2 | 3.4815 | 0.0685 | 0.000357613 | 0.00459235 | GAS 10
1192180 | Nivel 2 | 3.37687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 10
1192182 | Nivel 2 | 2.365 | 0.25813 | 0.000357613 | 0.0173055 | GAS 10
1192184 | Nivel 2 | 2.365 | 0.25813 | 0.000357613 | 0.0173055 | GAS 10
1192195 | Nivel 2 | 2.6421 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 10
1192197 | Nivel 2 | 2.365 | 0.446255 | 0.000357613 | 0.0299177 | GAS 10
1192201 | Nivel 2 | 2.83023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 10
1192207 | Nivel 2 | 2.33023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 12
1192213 | Nivel 2 | 2.33023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 12
1192215 | Nivel 2 | 2.33023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 12
1192217 | Nivel 2 | 2.6421 | 0.100378 | 0.000357613 | 0.00672947 | GAS 12
1192219 | Nivel 2 | 2.33023 | 2.15126 | 0.000357613 | 0.144224 | GAS 12
1192221 | Nivel 2 | 2.33023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 12
1192227 | Nivel 2 | 2.33023 | 2.82126 | 0.000357613 | 0.189141 | GAS 12
1192229 | Nivel 2 | 2.33023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 12
1192233 | Nivel 2 | 2.33023 | 0.419323 | 0.000357613 | 0.0281121 | GAS 12
1192237 | Nivel 2 | 2.365 | 0.95813 | 0.000357613 | 0.0642346 | GAS 12
1192241 | Nivel 2 | 3.3421 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 12
1192247 | Nivel 2 | 3.4815 | 0.0685 | 0.000357613 | 0.00459235 | GAS 12
1192250 | Nivel 2 | 3.37687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 12
1192252 | Nivel 2 | 2.365 | 0.25813 | 0.000357613 | 0.0173055 | GAS 12
1192254 | Nivel 2 | 2.365 | 0.25813 | 0.000357613 | 0.0173055 | GAS 12
1192265 | Nivel 2 | 2.6421 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 12
1192267 | Nivel 2 | 2.365 | 0.446255 | 0.000357613 | 0.0299177 | GAS 12
1192271 | Nivel 2 | 2.83023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 12
1192277 | Nivel 2 | 2.33019 | 0.221255 | 0.000357613 | 0.0148333 | GAS 4
1192281 | Nivel 2 | 2.3302 | 1.94126 | 0.000357613 | 0.130145 | GAS 1
1192285 | Nivel 2 | 2.3302 | 4.66626 | 0.000357613 | 0.312833 | GAS 12
1192287 | Nivel 2 | 2.3302 | 1.94126 | 0.000357613 | 0.130145 | GAS 12
1192291 | Nivel 2 | 2.3302 | 1.58626 | 0.000357613 | 0.106345 | GAS 10
1192295 | Nivel 2 | 2.3302 | 3.45878 | 0.000357613 | 0.231882 | GAS 10
1192299 | Nivel 2 | 2.3302 | 1.86126 | 0.000357613 | 0.124782 | GAS 10
1192303 | Nivel 2 | 2.36496 | 0.11504 | 0.000357613 | 0.00771243 | GAS 4
1192307 | Nivel 2 | 2.36497 | 0.115028 | 0.000357613 | 0.00771163 | GAS 1
1192311 | Nivel 2 | 2.36497 | 0.115028 | 0.000357613 | 0.00771163 | GAS 12
1192315 | Nivel 2 | 2.36497 | 0.115028 | 0.000357613 | 0.00771163 | GAS 10
1192349 | Nivel 3 | 4.68023 | 0.851229 | 0.000357613 | 0.0570677 | GAS 3
1192351 | Nivel 3 | 4.68023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 3
1192357 | Nivel 3 | 4.68023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 3
1192359 | Nivel 3 | 4.68023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 3
1192361 | Nivel 3 | 4.9921 | 0.100378 | 0.000357613 | 0.00672947 | GAS 3
1192363 | Nivel 3 | 4.68023 | 2.15126 | 0.000357613 | 0.144224 | GAS 3
1192365 | Nivel 3 | 4.68023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 3
1192371 | Nivel 3 | 4.68023 | 2.82126 | 0.000357613 | 0.189141 | GAS 3
1192373 | Nivel 3 | 4.68023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 3
1192377 | Nivel 3 | 4.68023 | 0.419323 | 0.000357613 | 0.0281121 | GAS 3
1192381 | Nivel 3 | 4.715 | 0.95813 | 0.000357613 | 0.0642346 | GAS 3
1192385 | Nivel 3 | 5.6921 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 3
1192391 | Nivel 3 | 5.8315 | 0.0685 | 0.000357613 | 0.00459235 | GAS 3
1192394 | Nivel 3 | 5.72687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 3
1192396 | Nivel 3 | 4.715 | 0.25813 | 0.000357613 | 0.0173055 | GAS 3
1192398 | Nivel 3 | 4.715 | 0.25813 | 0.000357613 | 0.0173055 | GAS 3
1192409 | Nivel 3 | 4.9921 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 3
1192411 | Nivel 3 | 4.715 | 0.446255 | 0.000357613 | 0.0299177 | GAS 3
1192415 | Nivel 3 | 5.18023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 3
1192421 | Nivel 3 | 4.68022 | 0.756255 | 0.000357613 | 0.0507005 | GAS 11
1192423 | Nivel 3 | 4.68023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 11
1192429 | Nivel 3 | 4.68023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 11
1192431 | Nivel 3 | 4.68023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 11
1192433 | Nivel 3 | 4.9921 | 0.100378 | 0.000357613 | 0.00672947 | GAS 11
1192435 | Nivel 3 | 4.68023 | 2.15126 | 0.000357613 | 0.144224 | GAS 11
1192437 | Nivel 3 | 4.68023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 11
1192443 | Nivel 3 | 4.68023 | 2.82126 | 0.000357613 | 0.189141 | GAS 11
1192445 | Nivel 3 | 4.68023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 11
1192449 | Nivel 3 | 4.68023 | 0.419323 | 0.000357613 | 0.0281121 | GAS 11
1192453 | Nivel 3 | 4.715 | 0.95813 | 0.000357613 | 0.0642346 | GAS 11
1192457 | Nivel 3 | 5.6921 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 11
1192463 | Nivel 3 | 5.8315 | 0.0685 | 0.000357613 | 0.00459235 | GAS 11
1192466 | Nivel 3 | 5.72687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 11
1192468 | Nivel 3 | 4.715 | 0.25813 | 0.000357613 | 0.0173055 | GAS 11
1192470 | Nivel 3 | 4.715 | 0.25813 | 0.000357613 | 0.0173055 | GAS 11
1192481 | Nivel 3 | 4.9921 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 11
1192483 | Nivel 3 | 4.715 | 0.446255 | 0.000357613 | 0.0299177 | GAS 11
1192487 | Nivel 3 | 5.18023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 11
1192493 | Nivel 3 | 4.68023 | 1.04626 | 0.000357613 | 0.0701426 | GAS 14
1192495 | Nivel 3 | 4.68023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 14
1192501 | Nivel 3 | 4.68023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 14
1192503 | Nivel 3 | 4.68023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 14
1192505 | Nivel 3 | 4.9921 | 0.100378 | 0.000357613 | 0.00672947 | GAS 14
1192507 | Nivel 3 | 4.68023 | 2.15126 | 0.000357613 | 0.144224 | GAS 14
1192509 | Nivel 3 | 4.68023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 14
1192515 | Nivel 3 | 4.68023 | 2.82126 | 0.000357613 | 0.189141 | GAS 14
1192517 | Nivel 3 | 4.68023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 14
1192521 | Nivel 3 | 4.68023 | 0.419323 | 0.000357613 | 0.0281121 | GAS 14
1192525 | Nivel 3 | 4.715 | 0.95813 | 0.000357613 | 0.0642346 | GAS 14
1192529 | Nivel 3 | 5.6921 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 14
1192535 | Nivel 3 | 5.8315 | 0.0685 | 0.000357613 | 0.00459235 | GAS 14
1192538 | Nivel 3 | 5.72687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 14
1192540 | Nivel 3 | 4.715 | 0.25813 | 0.000357613 | 0.0173055 | GAS 14
1192542 | Nivel 3 | 4.715 | 0.25813 | 0.000357613 | 0.0173055 | GAS 14
1192553 | Nivel 3 | 4.9921 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 14
1192555 | Nivel 3 | 4.715 | 0.446255 | 0.000357613 | 0.0299177 | GAS 14
1192559 | Nivel 3 | 5.18023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 14
1192565 | Nivel 3 | 4.68023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 16
1192571 | Nivel 3 | 4.68023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 16
1192573 | Nivel 3 | 4.68023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 16
1192575 | Nivel 3 | 4.9921 | 0.100378 | 0.000357613 | 0.00672947 | GAS 16
1192577 | Nivel 3 | 4.68023 | 2.15126 | 0.000357613 | 0.144224 | GAS 16
1192579 | Nivel 3 | 4.68023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 16
1192585 | Nivel 3 | 4.68023 | 2.82126 | 0.000357613 | 0.189141 | GAS 16
1192587 | Nivel 3 | 4.68023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 16
1192591 | Nivel 3 | 4.68023 | 0.419323 | 0.000357613 | 0.0281121 | GAS 16
1192595 | Nivel 3 | 4.715 | 0.95813 | 0.000357613 | 0.0642346 | GAS 16
1192599 | Nivel 3 | 5.6921 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 16
1192605 | Nivel 3 | 5.8315 | 0.0685 | 0.000357613 | 0.00459235 | GAS 16
1192608 | Nivel 3 | 5.72687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 16
1192610 | Nivel 3 | 4.715 | 0.25813 | 0.000357613 | 0.0173055 | GAS 16
1192612 | Nivel 3 | 4.715 | 0.25813 | 0.000357613 | 0.0173055 | GAS 16
1192623 | Nivel 3 | 4.9921 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 16
1192625 | Nivel 3 | 4.715 | 0.446255 | 0.000357613 | 0.0299177 | GAS 16
1192629 | Nivel 3 | 5.18023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 16
1192635 | Nivel 3 | 4.68019 | 0.226255 | 0.000357613 | 0.0151685 | GAS 11
1192639 | Nivel 3 | 4.6802 | 1.94626 | 0.000357613 | 0.13048 | GAS 3
1192643 | Nivel 3 | 4.6802 | 4.66626 | 0.000357613 | 0.312833 | GAS 16
1192645 | Nivel 3 | 4.6802 | 1.94626 | 0.000357613 | 0.13048 | GAS 16
1192649 | Nivel 3 | 4.6802 | 1.58626 | 0.000357613 | 0.106345 | GAS 14
1192653 | Nivel 3 | 4.6802 | 3.45878 | 0.000357613 | 0.231882 | GAS 14
1192657 | Nivel 3 | 4.6802 | 1.86626 | 0.000357613 | 0.125117 | GAS 14
1192661 | Nivel 3 | 4.71496 | 0.11504 | 0.000357613 | 0.00771243 | GAS 11
1192665 | Nivel 3 | 4.71497 | 0.115028 | 0.000357613 | 0.00771163 | GAS 3
1192669 | Nivel 3 | 4.71497 | 0.115028 | 0.000357613 | 0.00771163 | GAS 16
1192673 | Nivel 3 | 4.71497 | 0.115028 | 0.000357613 | 0.00771163 | GAS 14
1192707 | Nivel 4 | 7.03023 | 0.851254 | 0.000357613 | 0.0570694 | GAS 7
1192709 | Nivel 4 | 7.03023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 7
1192715 | Nivel 4 | 7.03023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 7
1192717 | Nivel 4 | 7.03023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 7
1192719 | Nivel 4 | 7.3421 | 0.100378 | 0.000357613 | 0.00672947 | GAS 7
1192721 | Nivel 4 | 7.03023 | 2.15126 | 0.000357613 | 0.144224 | GAS 7
1192723 | Nivel 4 | 7.03023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 7
1192729 | Nivel 4 | 7.03023 | 2.82126 | 0.000357613 | 0.189141 | GAS 7
1192731 | Nivel 4 | 7.03023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 7
1192735 | Nivel 4 | 7.03023 | 0.419323 | 0.000357613 | 0.0281121 | GAS 7
1192739 | Nivel 4 | 7.065 | 0.95813 | 0.000357613 | 0.0642346 | GAS 7
1192743 | Nivel 4 | 8.0421 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 7
1192749 | Nivel 4 | 8.1815 | 0.0685 | 0.000357613 | 0.00459235 | GAS 7
1192752 | Nivel 4 | 8.07687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 7
1192754 | Nivel 4 | 7.065 | 0.25813 | 0.000357613 | 0.0173055 | GAS 7
1192756 | Nivel 4 | 7.065 | 0.25813 | 0.000357613 | 0.0173055 | GAS 7
1192767 | Nivel 4 | 7.3421 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 7
1192769 | Nivel 4 | 7.065 | 0.446255 | 0.000357613 | 0.0299177 | GAS 7
1192773 | Nivel 4 | 7.53023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 7
1192779 | Nivel 4 | 7.03023 | 0.756255 | 0.000357613 | 0.0507005 | GAS 15
1192781 | Nivel 4 | 7.03023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 15
1192787 | Nivel 4 | 7.03023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 15
1192789 | Nivel 4 | 7.03023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 15
1192791 | Nivel 4 | 7.3421 | 0.100378 | 0.000357613 | 0.00672947 | GAS 15
1192793 | Nivel 4 | 7.03023 | 2.15126 | 0.000357613 | 0.144224 | GAS 15
1192795 | Nivel 4 | 7.03023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 15
1192801 | Nivel 4 | 7.03023 | 2.82126 | 0.000357613 | 0.189141 | GAS 15
1192803 | Nivel 4 | 7.03023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 15
1192807 | Nivel 4 | 7.03023 | 0.419323 | 0.000357613 | 0.0281121 | GAS 15
1192811 | Nivel 4 | 7.065 | 0.95813 | 0.000357613 | 0.0642346 | GAS 15
1192815 | Nivel 4 | 8.0421 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 15
1192821 | Nivel 4 | 8.1815 | 0.0685 | 0.000357613 | 0.00459235 | GAS 15
1192824 | Nivel 4 | 8.07687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 15
1192826 | Nivel 4 | 7.065 | 0.25813 | 0.000357613 | 0.0173055 | GAS 15
1192828 | Nivel 4 | 7.065 | 0.25813 | 0.000357613 | 0.0173055 | GAS 15
1192839 | Nivel 4 | 7.3421 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 15
1192841 | Nivel 4 | 7.065 | 0.446255 | 0.000357613 | 0.0299177 | GAS 15
1192845 | Nivel 4 | 7.53023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 15
1192851 | Nivel 4 | 7.03023 | 1.04626 | 0.000357613 | 0.0701426 | GAS 18
1192853 | Nivel 4 | 7.03023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 18
1192859 | Nivel 4 | 7.03023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 18
1192861 | Nivel 4 | 7.03023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 18
1192863 | Nivel 4 | 7.3421 | 0.100378 | 0.000357613 | 0.00672947 | GAS 18
1192865 | Nivel 4 | 7.03023 | 2.15126 | 0.000357613 | 0.144224 | GAS 18
1192867 | Nivel 4 | 7.03023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 18
1192873 | Nivel 4 | 7.03023 | 2.82126 | 0.000357613 | 0.189141 | GAS 18
1192875 | Nivel 4 | 7.03023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 18
1192879 | Nivel 4 | 7.03023 | 0.419323 | 0.000357613 | 0.0281121 | GAS 18
1192883 | Nivel 4 | 7.065 | 0.95813 | 0.000357613 | 0.0642346 | GAS 18
1192887 | Nivel 4 | 8.0421 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 18
1192893 | Nivel 4 | 8.1815 | 0.0685 | 0.000357613 | 0.00459235 | GAS 18
1192896 | Nivel 4 | 8.07687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 18
1192898 | Nivel 4 | 7.065 | 0.25813 | 0.000357613 | 0.0173055 | GAS 18
1192900 | Nivel 4 | 7.065 | 0.25813 | 0.000357613 | 0.0173055 | GAS 18
1192911 | Nivel 4 | 7.3421 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 18
1192913 | Nivel 4 | 7.065 | 0.446255 | 0.000357613 | 0.0299177 | GAS 18
1192917 | Nivel 4 | 7.53023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 18
1192923 | Nivel 4 | 7.03023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 20
1192929 | Nivel 4 | 7.03023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 20
1192931 | Nivel 4 | 7.03023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 20
1192933 | Nivel 4 | 7.3421 | 0.100378 | 0.000357613 | 0.00672947 | GAS 20
1192935 | Nivel 4 | 7.03023 | 2.15126 | 0.000357613 | 0.144224 | GAS 20
1192937 | Nivel 4 | 7.03023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 20
1192943 | Nivel 4 | 7.03023 | 2.82126 | 0.000357613 | 0.189141 | GAS 20
1192945 | Nivel 4 | 7.03023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 20
1192949 | Nivel 4 | 7.03023 | 0.419323 | 0.000357613 | 0.0281121 | GAS 20
1192953 | Nivel 4 | 7.065 | 0.95813 | 0.000357613 | 0.0642346 | GAS 20
1192957 | Nivel 4 | 8.0421 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 20
1192963 | Nivel 4 | 8.1815 | 0.0685 | 0.000357613 | 0.00459235 | GAS 20
1192966 | Nivel 4 | 8.07687 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 20
1192968 | Nivel 4 | 7.065 | 0.25813 | 0.000357613 | 0.0173055 | GAS 20
1192970 | Nivel 4 | 7.065 | 0.25813 | 0.000357613 | 0.0173055 | GAS 20
1192981 | Nivel 4 | 7.3421 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 20
1192983 | Nivel 4 | 7.065 | 0.446255 | 0.000357613 | 0.0299177 | GAS 20
1192987 | Nivel 4 | 7.53023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 20
1192993 | Nivel 4 | 7.03019 | 0.216255 | 0.000357613 | 0.0144981 | GAS 15
1192997 | Nivel 4 | 7.0302 | 1.93626 | 0.000357613 | 0.12981 | GAS 7
1193001 | Nivel 4 | 7.0302 | 4.66626 | 0.000357613 | 0.312833 | GAS 20
1193003 | Nivel 4 | 7.0302 | 1.93626 | 0.000357613 | 0.12981 | GAS 20
1193007 | Nivel 4 | 7.0302 | 1.58626 | 0.000357613 | 0.106345 | GAS 18
1193011 | Nivel 4 | 7.0302 | 3.45878 | 0.000357613 | 0.231882 | GAS 18
1193015 | Nivel 4 | 7.0302 | 1.85626 | 0.000357613 | 0.124446 | GAS 18
1193019 | Nivel 4 | 7.06496 | 0.11504 | 0.000357613 | 0.00771243 | GAS 15
1193023 | Nivel 4 | 7.06497 | 0.115028 | 0.000357613 | 0.00771163 | GAS 7
1193027 | Nivel 4 | 7.06497 | 0.115028 | 0.000357613 | 0.00771163 | GAS 20
1193031 | Nivel 4 | 7.06497 | 0.115028 | 0.000357613 | 0.00771163 | GAS 18
1193065 | Nivel 5 | 9.38023 | 0.851254 | 0.000357613 | 0.0570694 | GAS 13
1193067 | Nivel 5 | 9.38023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 13
1193073 | Nivel 5 | 9.38023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 13
1193075 | Nivel 5 | 9.38023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 13
1193077 | Nivel 5 | 9.6921 | 0.100378 | 0.000357613 | 0.00672947 | GAS 13
1193079 | Nivel 5 | 9.38023 | 2.15126 | 0.000357613 | 0.144224 | GAS 13
1193081 | Nivel 5 | 9.38023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 13
1193087 | Nivel 5 | 9.38023 | 2.82126 | 0.000357613 | 0.189141 | GAS 13
1193089 | Nivel 5 | 9.38023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 13
1193093 | Nivel 5 | 9.38023 | 0.419323 | 0.000357613 | 0.0281121 | GAS 13
1193097 | Nivel 5 | 9.415 | 0.95813 | 0.000357613 | 0.0642346 | GAS 13
1193101 | Nivel 5 | 10.3921 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 13
1193107 | Nivel 5 | 10.5315 | 0.0685 | 0.000357613 | 0.00459235 | GAS 13
1193110 | Nivel 5 | 10.4269 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 13
1193112 | Nivel 5 | 9.415 | 0.25813 | 0.000357613 | 0.0173055 | GAS 13
1193114 | Nivel 5 | 9.415 | 0.25813 | 0.000357613 | 0.0173055 | GAS 13
1193125 | Nivel 5 | 9.6921 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 13
1193127 | Nivel 5 | 9.415 | 0.446255 | 0.000357613 | 0.0299177 | GAS 13
1193131 | Nivel 5 | 9.88023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 13
1193137 | Nivel 5 | 9.38023 | 0.756255 | 0.000357613 | 0.0507005 | GAS 19
1193139 | Nivel 5 | 9.38023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 19
1193145 | Nivel 5 | 9.38023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 19
1193147 | Nivel 5 | 9.38023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 19
1193149 | Nivel 5 | 9.6921 | 0.100378 | 0.000357613 | 0.00672947 | GAS 19
1193151 | Nivel 5 | 9.38023 | 2.15126 | 0.000357613 | 0.144224 | GAS 19
1193153 | Nivel 5 | 9.38023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 19
1193159 | Nivel 5 | 9.38023 | 2.82126 | 0.000357613 | 0.189141 | GAS 19
1193161 | Nivel 5 | 9.38023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 19
1193165 | Nivel 5 | 9.38023 | 0.419323 | 0.000357613 | 0.0281121 | GAS 19
1193169 | Nivel 5 | 9.415 | 0.95813 | 0.000357613 | 0.0642346 | GAS 19
1193173 | Nivel 5 | 10.3921 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 19
1193179 | Nivel 5 | 10.5315 | 0.0685 | 0.000357613 | 0.00459235 | GAS 19
1193182 | Nivel 5 | 10.4269 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 19
1193184 | Nivel 5 | 9.415 | 0.25813 | 0.000357613 | 0.0173055 | GAS 19
1193186 | Nivel 5 | 9.415 | 0.25813 | 0.000357613 | 0.0173055 | GAS 19
1193197 | Nivel 5 | 9.6921 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 19
1193199 | Nivel 5 | 9.415 | 0.446255 | 0.000357613 | 0.0299177 | GAS 19
1193203 | Nivel 5 | 9.88023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 19
1193209 | Nivel 5 | 9.38023 | 1.04626 | 0.000357613 | 0.0701426 | GAS 22
1193211 | Nivel 5 | 9.38023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 22
1193217 | Nivel 5 | 9.38023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 22
1193219 | Nivel 5 | 9.38023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 22
1193221 | Nivel 5 | 9.6921 | 0.100378 | 0.000357613 | 0.00672947 | GAS 22
1193223 | Nivel 5 | 9.38023 | 2.15126 | 0.000357613 | 0.144224 | GAS 22
1193225 | Nivel 5 | 9.38023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 22
1193231 | Nivel 5 | 9.38023 | 2.82126 | 0.000357613 | 0.189141 | GAS 22
1193233 | Nivel 5 | 9.38023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 22
1193237 | Nivel 5 | 9.38023 | 0.419323 | 0.000357613 | 0.0281121 | GAS 22
1193241 | Nivel 5 | 9.415 | 0.95813 | 0.000357613 | 0.0642346 | GAS 22
1193245 | Nivel 5 | 10.3921 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 22
1193251 | Nivel 5 | 10.5315 | 0.0685 | 0.000357613 | 0.00459235 | GAS 22
1193254 | Nivel 5 | 10.4269 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 22
1193256 | Nivel 5 | 9.415 | 0.25813 | 0.000357613 | 0.0173055 | GAS 22
1193258 | Nivel 5 | 9.415 | 0.25813 | 0.000357613 | 0.0173055 | GAS 22
1193269 | Nivel 5 | 9.6921 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 22
1193271 | Nivel 5 | 9.415 | 0.446255 | 0.000357613 | 0.0299177 | GAS 22
1193275 | Nivel 5 | 9.88023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 22
1193281 | Nivel 5 | 9.38023 | 0.583755 | 0.000357613 | 0.0391359 | GAS 24
1193287 | Nivel 5 | 9.38023 | 0.396255 | 0.000357613 | 0.0265656 | GAS 24
1193289 | Nivel 5 | 9.38023 | 0.116255 | 0.000357613 | 0.00779393 | GAS 24
1193291 | Nivel 5 | 9.6921 | 0.100378 | 0.000357613 | 0.00672947 | GAS 24
1193293 | Nivel 5 | 9.38023 | 2.15126 | 0.000357613 | 0.144224 | GAS 24
1193295 | Nivel 5 | 9.38023 | 0.808869 | 0.000357613 | 0.0542279 | GAS 24
1193301 | Nivel 5 | 9.38023 | 2.82126 | 0.000357613 | 0.189141 | GAS 24
1193303 | Nivel 5 | 9.38023 | 0.776255 | 0.000357613 | 0.0520414 | GAS 24
1193307 | Nivel 5 | 9.38023 | 0.419323 | 0.000357613 | 0.0281121 | GAS 24
1193311 | Nivel 5 | 9.415 | 0.95813 | 0.000357613 | 0.0642346 | GAS 24
1193315 | Nivel 5 | 10.3921 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 24
1193321 | Nivel 5 | 10.5315 | 0.0685 | 0.000357613 | 0.00459235 | GAS 24
1193324 | Nivel 5 | 10.4269 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 24
1193326 | Nivel 5 | 9.415 | 0.25813 | 0.000357613 | 0.0173055 | GAS 24
1193328 | Nivel 5 | 9.415 | 0.25813 | 0.000357613 | 0.0173055 | GAS 24
1193339 | Nivel 5 | 9.6921 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 24
1193341 | Nivel 5 | 9.415 | 0.446255 | 0.000357613 | 0.0299177 | GAS 24
1193345 | Nivel 5 | 9.88023 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 24
1193351 | Nivel 5 | 9.38019 | 0.216255 | 0.000357613 | 0.0144981 | GAS 19
1193355 | Nivel 5 | 9.3802 | 1.93626 | 0.000357613 | 0.12981 | GAS 13
1193359 | Nivel 5 | 9.3802 | 4.66626 | 0.000357613 | 0.312833 | GAS 24
1193361 | Nivel 5 | 9.3802 | 1.93626 | 0.000357613 | 0.12981 | GAS 24
1193365 | Nivel 5 | 9.3802 | 1.58626 | 0.000357613 | 0.106345 | GAS 22
1193369 | Nivel 5 | 9.3802 | 3.45878 | 0.000357613 | 0.231882 | GAS 22
1193373 | Nivel 5 | 9.3802 | 1.85626 | 0.000357613 | 0.124446 | GAS 22
1193377 | Nivel 5 | 9.41496 | 0.11504 | 0.000357613 | 0.00771243 | GAS 19
1193381 | Nivel 5 | 9.41497 | 0.115028 | 0.000357613 | 0.00771163 | GAS 13
1193385 | Nivel 5 | 9.41497 | 0.115028 | 0.000357613 | 0.00771163 | GAS 24
1193389 | Nivel 5 | 9.41497 | 0.115028 | 0.000357613 | 0.00771163 | GAS 22
1193423 | Nivel 6 | 11.7302 | 0.851254 | 0.000357613 | 0.0570694 | GAS 17
1193425 | Nivel 6 | 11.7302 | 0.583755 | 0.000357613 | 0.0391359 | GAS 17
1193431 | Nivel 6 | 11.7302 | 0.396255 | 0.000357613 | 0.0265656 | GAS 17
1193433 | Nivel 6 | 11.7302 | 0.116255 | 0.000357613 | 0.00779393 | GAS 17
1193435 | Nivel 6 | 12.0421 | 0.100378 | 0.000357613 | 0.00672947 | GAS 17
1193437 | Nivel 6 | 11.7302 | 2.15126 | 0.000357613 | 0.144224 | GAS 17
1193439 | Nivel 6 | 11.7302 | 0.831256 | 0.000357613 | 0.0557287 | GAS 17
1193445 | Nivel 6 | 11.7302 | 2.82126 | 0.000357613 | 0.189141 | GAS 17
1193447 | Nivel 6 | 11.7302 | 0.776255 | 0.000357613 | 0.0520414 | GAS 17
1193451 | Nivel 6 | 11.7302 | 0.419323 | 0.000357613 | 0.0281121 | GAS 17
1193455 | Nivel 6 | 11.765 | 0.95813 | 0.000357613 | 0.0642346 | GAS 17
1193459 | Nivel 6 | 12.7421 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 17
1193465 | Nivel 6 | 12.8815 | 0.0685 | 0.000357613 | 0.00459235 | GAS 17
1193468 | Nivel 6 | 12.7769 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 17
1193470 | Nivel 6 | 11.765 | 0.25813 | 0.000357613 | 0.0173055 | GAS 17
1193472 | Nivel 6 | 11.765 | 0.25813 | 0.000357613 | 0.0173055 | GAS 17
1193483 | Nivel 6 | 12.0421 | 0.0628773 | 0.000357613 | 0.00421539 | GAS 17
1193485 | Nivel 6 | 11.765 | 0.446255 | 0.000357613 | 0.0299177 | GAS 17
1193489 | Nivel 6 | 12.2302 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 17
1193495 | Nivel 6 | 11.7302 | 0.756255 | 0.000357613 | 0.0507005 | GAS 23
1193497 | Nivel 6 | 11.7302 | 0.583755 | 0.000357613 | 0.0391359 | GAS 23
1193503 | Nivel 6 | 11.7302 | 0.396255 | 0.000357613 | 0.0265656 | GAS 23
1193505 | Nivel 6 | 11.7302 | 0.116255 | 0.000357613 | 0.00779393 | GAS 23
1193507 | Nivel 6 | 12.0421 | 0.100378 | 0.000357613 | 0.00672947 | GAS 23
1193509 | Nivel 6 | 11.7302 | 2.15126 | 0.000357613 | 0.144224 | GAS 23
1193511 | Nivel 6 | 11.7302 | 0.808869 | 0.000357613 | 0.0542279 | GAS 23
1193517 | Nivel 6 | 11.7302 | 2.82126 | 0.000357613 | 0.189141 | GAS 23
1193519 | Nivel 6 | 11.7302 | 0.776255 | 0.000357613 | 0.0520414 | GAS 23
1193523 | Nivel 6 | 11.7302 | 0.419323 | 0.000357613 | 0.0281121 | GAS 23
1193527 | Nivel 6 | 11.765 | 0.95813 | 0.000357613 | 0.0642346 | GAS 23
1193531 | Nivel 6 | 12.7421 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 23
1193537 | Nivel 6 | 12.8815 | 0.0685 | 0.000357613 | 0.00459235 | GAS 23
1193540 | Nivel 6 | 12.7769 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 23
1193542 | Nivel 6 | 11.765 | 0.25813 | 0.000357613 | 0.0173055 | GAS 23
1193544 | Nivel 6 | 11.765 | 0.25813 | 0.000357613 | 0.0173055 | GAS 23
1193555 | Nivel 6 | 12.0421 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 23
1193557 | Nivel 6 | 11.765 | 0.446255 | 0.000357613 | 0.0299177 | GAS 23
1193561 | Nivel 6 | 12.2302 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 23
1193567 | Nivel 6 | 11.7302 | 1.04626 | 0.000357613 | 0.0701426 | GAS 26
1193569 | Nivel 6 | 11.7302 | 0.583755 | 0.000357613 | 0.0391359 | GAS 26
1193575 | Nivel 6 | 11.7302 | 0.396255 | 0.000357613 | 0.0265656 | GAS 26
1193577 | Nivel 6 | 11.7302 | 0.116255 | 0.000357613 | 0.00779393 | GAS 26
1193579 | Nivel 6 | 12.0421 | 0.100378 | 0.000357613 | 0.00672947 | GAS 26
1193581 | Nivel 6 | 11.7302 | 2.15126 | 0.000357613 | 0.144224 | GAS 26
1193583 | Nivel 6 | 11.7302 | 0.808869 | 0.000357613 | 0.0542279 | GAS 26
1193589 | Nivel 6 | 11.7302 | 2.82126 | 0.000357613 | 0.189141 | GAS 26
1193591 | Nivel 6 | 11.7302 | 0.776255 | 0.000357613 | 0.0520414 | GAS 26
1193595 | Nivel 6 | 11.7302 | 0.419323 | 0.000357613 | 0.0281121 | GAS 26
1193599 | Nivel 6 | 11.765 | 0.95813 | 0.000357613 | 0.0642346 | GAS 26
1193603 | Nivel 6 | 12.7421 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 26
1193609 | Nivel 6 | 12.8815 | 0.0685 | 0.000357613 | 0.00459235 | GAS 26
1193612 | Nivel 6 | 12.7769 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 26
1193614 | Nivel 6 | 11.765 | 0.25813 | 0.000357613 | 0.0173055 | GAS 26
1193616 | Nivel 6 | 11.765 | 0.25813 | 0.000357613 | 0.0173055 | GAS 26
1193627 | Nivel 6 | 12.0421 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 26
1193629 | Nivel 6 | 11.765 | 0.446255 | 0.000357613 | 0.0299177 | GAS 26
1193633 | Nivel 6 | 12.2302 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 26
1193639 | Nivel 6 | 11.7302 | 0.583755 | 0.000357613 | 0.0391359 | GAS 28
1193645 | Nivel 6 | 11.7302 | 0.396255 | 0.000357613 | 0.0265656 | GAS 28
1193647 | Nivel 6 | 11.7302 | 0.116255 | 0.000357613 | 0.00779393 | GAS 28
1193649 | Nivel 6 | 12.0421 | 0.100378 | 0.000357613 | 0.00672947 | GAS 28
1193651 | Nivel 6 | 11.7302 | 2.15126 | 0.000357613 | 0.144224 | GAS 28
1193653 | Nivel 6 | 11.7302 | 0.808869 | 0.000357613 | 0.0542279 | GAS 28
1193659 | Nivel 6 | 11.7302 | 2.82126 | 0.000357613 | 0.189141 | GAS 28
1193661 | Nivel 6 | 11.7302 | 0.776255 | 0.000357613 | 0.0520414 | GAS 28
1193665 | Nivel 6 | 11.7302 | 0.419323 | 0.000357613 | 0.0281121 | GAS 28
1193669 | Nivel 6 | 11.765 | 0.95813 | 0.000357613 | 0.0642346 | GAS 28
1193673 | Nivel 6 | 12.7421 | 0.0456246 | 0.000357613 | 0.00305875 | GAS 28
1193679 | Nivel 6 | 12.8815 | 0.0685 | 0.000357613 | 0.00459235 | GAS 28
1193682 | Nivel 6 | 12.7769 | 0.0416276 | 0.000357613 | 0.00279078 | GAS 28
1193684 | Nivel 6 | 11.765 | 0.25813 | 0.000357613 | 0.0173055 | GAS 28
1193686 | Nivel 6 | 11.765 | 0.25813 | 0.000357613 | 0.0173055 | GAS 28
1193697 | Nivel 6 | 12.0421 | 0.0852639 | 0.000357613 | 0.00571622 | GAS 28
1193699 | Nivel 6 | 11.765 | 0.446255 | 0.000357613 | 0.0299177 | GAS 28
1193703 | Nivel 6 | 12.2302 | 0.0381276 | 0.000357613 | 0.00255613 | GAS 28
1193709 | Nivel 6 | 11.7302 | 0.216255 | 0.000357613 | 0.0144981 | GAS 23
1193713 | Nivel 6 | 11.7302 | 1.93626 | 0.000357613 | 0.12981 | GAS 17
1193717 | Nivel 6 | 11.7302 | 4.66626 | 0.000357613 | 0.312833 | GAS 28
1193719 | Nivel 6 | 11.7302 | 1.93626 | 0.000357613 | 0.12981 | GAS 28
1193723 | Nivel 6 | 11.7302 | 1.58626 | 0.000357613 | 0.106345 | GAS 26
1193727 | Nivel 6 | 11.7302 | 3.45878 | 0.000357613 | 0.231882 | GAS 26
1193731 | Nivel 6 | 11.7302 | 1.85626 | 0.000357613 | 0.124446 | GAS 26
1193735 | Nivel 6 | 11.765 | 0.11504 | 0.000357613 | 0.00771243 | GAS 23
1193739 | Nivel 6 | 11.765 | 0.115028 | 0.000357613 | 0.00771163 | GAS 17
1193743 | Nivel 6 | 11.765 | 0.115028 | 0.000357613 | 0.00771163 | GAS 28
1193747 | Nivel 6 | 11.765 | 0.115028 | 0.000357613 | 0.00771163 | GAS 26
1208936 | Nivel 1 | -0.592742 | 3.85664 | 0.000876079 | 0.404686 | GAS 2
1330722 | Nivel 1 | -0.592737 | 0.0464968 | 0.000876079 | 0.00487901 | GAS 2
1330727 | Nivel 1 | -0.542625 | 0.305178 | 0.000876079 | 0.032023 | GAS 2

# IfcPipeSegment: Pipe Types:D2060-POLIETILENO, Pipe Types:D2060-POLIETILENO:1311128
In: Nivel 1
Type - PredefinedType: RIGIDSEGMENT
Classification: 21.04.30.10.10 Uniformat (Uniformat); Group: GAS 27
Pset_EnvironmentalImpactIndicators - Reference: D2060-POLIETILENO; sets with these values: 2
Pset_PipeSegmentOccurrence - InvertElevation: -0.5544 m
Qto_PipeSegmentBaseQuantities - Length: 0.4544 m; GrossCrossSectionArea: 0.000876027 m2; NetCrossSectionArea: 0.000876027 m2; OuterSurfaceArea: 0.0476798 m2

# IfcPipeSegment: Pipe Types:D4010-ACERO AL CARBON (20)
Type - PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - Manufacturer: Victaulic
Classification: 21.04.40.10.10 Uniformat (Uniformat); Group: RCI 1
Pset_EnvironmentalImpactIndicators - Reference: D4010-ACERO AL CARBON; sets with these values: 2
Name (Pipe Types:D4010-ACERO AL CARBON:...) | In | InvertElevation (m) | Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2)
1057223 | Nivel 1 | 0.0580191 | 1.30744 | 0.0102593 | 0.469482
1057414 | Nivel 1 | 1.46428 | 0.3876 | 0.00418762 | 0.0889212
1057427 | Nivel 1 | 13.3752 | 0.79865 | 0.0102593 | 0.286782
1057472 | Nivel 1 | 1.46428 | 0.0486949 | 0.00418762 | 0.0111713
1058910 | Nivel 2 | 3.81365 | 0.3876 | 0.00418762 | 0.0889212
1058912 | Nivel 2 | 3.81365 | 0.0486949 | 0.00418762 | 0.0111713
1058937 | Nivel 3 | 6.16365 | 0.3876 | 0.00418762 | 0.0889212
1058939 | Nivel 3 | 6.16365 | 0.0486949 | 0.00418762 | 0.0111713
1058964 | Nivel 4 | 8.51365 | 0.3876 | 0.00418762 | 0.0889212
1058966 | Nivel 4 | 8.51365 | 0.0486949 | 0.00418762 | 0.0111713
1058991 | Nivel 5 | 10.8636 | 0.3876 | 0.00418762 | 0.0889212
1058993 | Nivel 5 | 10.8636 | 0.0486949 | 0.00418762 | 0.0111713
1059018 | Nivel 6 | 13.2136 | 0.3876 | 0.00418762 | 0.0889212
1059020 | Nivel 6 | 13.2136 | 0.0486949 | 0.00418762 | 0.0111713
1059114 | Nivel 1 | 11.0252 | 2.08965 | 0.0102593 | 0.75036
1059164 | Nivel 1 | 8.67518 | 2.08965 | 0.0102593 | 0.75036
1059214 | Nivel 1 | 6.32518 | 2.08965 | 0.0102593 | 0.75036
1059264 | Nivel 1 | 3.97518 | 2.08965 | 0.0102593 | 0.75036
1059314 | Nivel 1 | 1.62581 | 2.08901 | 0.0102593 | 0.750132
1202536 | Nivel 1 | 14.2564 | 0.077925 | 0.00285772 | 0.0147681

# IfcPipeSegment: Pipe Types:D4010-PVC.AWWA C900 (3)
In: Nivel 1
Type - PredefinedType: RIGIDSEGMENT
Classification: 21.04.40.10.10 Uniformat (Uniformat); Group: RCI 1
Pset_EnvironmentalImpactIndicators - Reference: D4010-PVC.AWWA C900; sets with these values: 2
Qto_PipeSegmentBaseQuantities - GrossCrossSectionArea: 0.011669 m2; NetCrossSectionArea: 0.011669 m2
Name (Pipe Types:D4010-PVC.AWWA C900:...) | InvertElevation (m) | Length (m) | OuterSurfaceArea (m2)
1055214 | -0.8729 | 3.8705 | 1.48225
1057089 | -0.8729 | 1.38025 | 0.528582
1057266 | -0.7192 | 0.724831 | 0.277581

# IfcValve: D2010 - VALVULA CORTE 2-6 PULG:50 mm, D2010 - VALVULA CORTE 2-6 PULG:50 mm:1198550
In: Nivel 1
Type - Material: <Unnamed>
Classification: 21.04.20.10.40 Uniformat (Uniformat); Group: AF 2
Pset_EnvironmentalImpactIndicators - Reference: 50 mm; sets with these values: 2

# IfcValve: M_Ball Valve - 50-150 mm:15 mm (49)
Type - Material: <Unnamed>
Classification: 21.04.20.10.40 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: 15 mm; sets with these values: 2
Name (M_Ball Valve - 50-150 mm:15 mm:...) | In | Group
963127 | Nivel 2 | AC 1
1063919 | Nivel 2 | AC 2
1065549 | Nivel 2 | AC 4
1066504 | Nivel 2 | AC 5
1106440 | Nivel 1 | AC 3
1106495 | Nivel 1 | AC 8
1106538 | Nivel 1 | AC 11
1106609 | Nivel 1 | AC 14
1110170 | Nivel 2 | AF 1
1110325 | Nivel 2 | AF 16
1110494 | Nivel 2 | AF 30
1110651 | Nivel 2 | AF 44
1112904 | Nivel 1 | AF 3
1113059 | Nivel 1 | AF 17
1113228 | Nivel 1 | AF 31
1113385 | Nivel 1 | AF 45
1113717 | Nivel 3 | AC 6
1113772 | Nivel 3 | AC 10
1113815 | Nivel 3 | AC 15
1113886 | Nivel 3 | AC 18
1114079 | Nivel 3 | AF 4
1114234 | Nivel 3 | AF 19
1114403 | Nivel 3 | AF 34
1114560 | Nivel 3 | AF 49
1114770 | Nivel 4 | AC 7
1114825 | Nivel 4 | AC 13
1114868 | Nivel 4 | AC 19
1114939 | Nivel 4 | AC 22
1115132 | Nivel 4 | AF 5
1115287 | Nivel 4 | AF 21
1115456 | Nivel 4 | AF 37
1115613 | Nivel 4 | AF 53
1115823 | Nivel 5 | AC 9
1115878 | Nivel 5 | AC 17
1115921 | Nivel 5 | AC 23
1115992 | Nivel 5 | AC 26
1116185 | Nivel 5 | AF 6
1116340 | Nivel 5 | AF 23
1116509 | Nivel 5 | AF 40
1116666 | Nivel 5 | AF 57
1116864 | Nivel 6 | AC 12
1116919 | Nivel 6 | AC 21
1116962 | Nivel 6 | AC 27
1117033 | Nivel 6 | AC 30
1117226 | Nivel 6 | AF 7
1117381 | Nivel 6 | AC 16
1117550 | Nivel 6 | AF 43
1117707 | Nivel 6 | AF 61
1203633 | Nivel 1 | AF 2

# IfcValve: M_Pressure Regulating Valve - 15-50 mm - Threaded:15 mm, M_Pressure Regulating Valve - 15-50 mm - Threaded:15 mm:1062377
In: Nivel 1
Type - Material: <Unnamed>
Classification: 21.04.20.10.40 Uniformat (Uniformat); Group: AF 2
Pset_EnvironmentalImpactIndicators - Reference: 15 mm; sets with these values: 2

# IfcValve: M_Pressure Regulating Valve - 15-50 mm - Threaded:20 mm, M_Pressure Regulating Valve - 15-50 mm - Threaded:20 mm:1207516
In: Nivel 1
Type - Material: <Unnamed>
Classification: 21.04.40.10.10 Uniformat (Uniformat); Group: RCI 1
Pset_EnvironmentalImpactIndicators - Reference: 20 mm; sets with these values: 2

# IfcValve: VALVULA DE INCENDIO:VALVULA DE INCENDIO (6)
Type - Material: <Unnamed>
Classification: 21.04.40.10.10 Uniformat (Uniformat); Group: RCI 1
Pset_EnvironmentalImpactIndicators - Reference: VALVULA DE INCENDIO; sets with these values: 2
Name (VALVULA DE INCENDIO:VALVULA DE INCENDIO:...) | In
1058417 | Nivel 1
1058920 | Nivel 2
1058947 | Nivel 3
1058974 | Nivel 4
1059001 | Nivel 5
1059028 | Nivel 6

# IfcValve: Valvula 0.75 y 1:25 mm, Valvula 0.75 y 1:25 mm:1208326
In: Nivel 1
Type - Material: <Unnamed>
Classification: 21.04.40.10.10 Uniformat (Uniformat); Group: RCI 1
Pset_EnvironmentalImpactIndicators - Reference: 25 mm; sets with these values: 2

# IfcValve: Valvula gas con convención:15 mm (48)
Type - Material: <Unnamed>
Classification: 21.04.30.10.10 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: 15 mm; sets with these values: 2
Name (Valvula gas con convención:15 mm:...) | In | Group
