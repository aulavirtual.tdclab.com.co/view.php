Properties of the parts of a building model (IFC4), part 21 of 21

# IfcValve: Valvula gas con convención:15 mm (48)
Name (Valvula gas con convención:15 mm:...) | In | Group
1105068 | Nivel 1 | GAS 5
1105083 | Nivel 1 | GAS 5
1118225 | Nivel 1 | GAS 6
1118240 | Nivel 1 | GAS 6
1118301 | Nivel 1 | GAS 8
1118316 | Nivel 1 | GAS 8
1118377 | Nivel 1 | GAS 9
1118392 | Nivel 1 | GAS 9
1192035 | Nivel 2 | GAS 1
1192050 | Nivel 2 | GAS 1
1192107 | Nivel 2 | GAS 4
1192122 | Nivel 2 | GAS 4
1192179 | Nivel 2 | GAS 10
1192194 | Nivel 2 | GAS 10
1192249 | Nivel 2 | GAS 12
1192264 | Nivel 2 | GAS 12
1192393 | Nivel 3 | GAS 3
1192408 | Nivel 3 | GAS 3
1192465 | Nivel 3 | GAS 11
1192480 | Nivel 3 | GAS 11
1192537 | Nivel 3 | GAS 14
1192552 | Nivel 3 | GAS 14
1192607 | Nivel 3 | GAS 16
1192622 | Nivel 3 | GAS 16
1192751 | Nivel 4 | GAS 7
1192766 | Nivel 4 | GAS 7
1192823 | Nivel 4 | GAS 15
1192838 | Nivel 4 | GAS 15
1192895 | Nivel 4 | GAS 18
1192910 | Nivel 4 | GAS 18
1192965 | Nivel 4 | GAS 20
1192980 | Nivel 4 | GAS 20
1193109 | Nivel 5 | GAS 13
1193124 | Nivel 5 | GAS 13
1193181 | Nivel 5 | GAS 19
1193196 | Nivel 5 | GAS 19
1193253 | Nivel 5 | GAS 22
1193268 | Nivel 5 | GAS 22
1193323 | Nivel 5 | GAS 24
1193338 | Nivel 5 | GAS 24
1193467 | Nivel 6 | GAS 17
1193482 | Nivel 6 | GAS 17
1193539 | Nivel 6 | GAS 23
1193554 | Nivel 6 | GAS 23
1193611 | Nivel 6 | GAS 26
1193626 | Nivel 6 | GAS 26
1193681 | Nivel 6 | GAS 28
1193696 | Nivel 6 | GAS 28
