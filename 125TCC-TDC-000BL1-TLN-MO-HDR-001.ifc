Properties of the parts of a building model (IFC4), part 17 of 21

# IfcPipeFitting: D2060 - Tapa roscada:Standard (24)
Name (D2060 - Tapa roscada:Standard:...) | In | Group
1192133 | Nivel 2 | GAS 4
1192205 | Nivel 2 | GAS 10
1192275 | Nivel 2 | GAS 12
1192419 | Nivel 3 | GAS 3
1192491 | Nivel 3 | GAS 11
1192563 | Nivel 3 | GAS 14
1192633 | Nivel 3 | GAS 16
1192777 | Nivel 4 | GAS 7
1192849 | Nivel 4 | GAS 15
1192921 | Nivel 4 | GAS 18
1192991 | Nivel 4 | GAS 20
1193135 | Nivel 5 | GAS 13
1193207 | Nivel 5 | GAS 19
1193279 | Nivel 5 | GAS 22
1193349 | Nivel 5 | GAS 24
1193493 | Nivel 6 | GAS 17
1193565 | Nivel 6 | GAS 23
1193637 | Nivel 6 | GAS 26
1193707 | Nivel 6 | GAS 28

# IfcPipeFitting: D2060 - Tee roscada:Standard (29)
Type - Material: <Unnamed>
Classification: 21.04.20.60.30 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D2060 - Tee roscada:Standard:...) | In | Group
1060589 | Nivel 1 | GAS 2
1060781 | Nivel 2 | GAS 2
1060817 | Nivel 3 | GAS 2
1060853 | Nivel 4 | GAS 2
1060889 | Nivel 5 | GAS 2
1105044 | Nivel 1 | GAS 5
1118201 | Nivel 1 | GAS 6
1118277 | Nivel 1 | GAS 8
1118353 | Nivel 1 | GAS 9
1192011 | Nivel 2 | GAS 1
1192083 | Nivel 2 | GAS 4
1192155 | Nivel 2 | GAS 10
1192225 | Nivel 2 | GAS 12
1192369 | Nivel 3 | GAS 3
1192441 | Nivel 3 | GAS 11
1192513 | Nivel 3 | GAS 14
1192583 | Nivel 3 | GAS 16
1192727 | Nivel 4 | GAS 7
1192799 | Nivel 4 | GAS 15
1192871 | Nivel 4 | GAS 18
1192941 | Nivel 4 | GAS 20
1193085 | Nivel 5 | GAS 13
1193157 | Nivel 5 | GAS 19
1193229 | Nivel 5 | GAS 22
1193299 | Nivel 5 | GAS 24
1193443 | Nivel 6 | GAS 17
1193515 | Nivel 6 | GAS 23
1193587 | Nivel 6 | GAS 26
1193657 | Nivel 6 | GAS 28

# IfcPipeFitting: D4010 - Victaulic-IPS-Elbow No 10-13:Standard (6)
Type - Material: <Unnamed>, Victaulic
Type - Pset_ManufacturerTypeInformation - Manufacturer: Victaulic
Classification: 21.04.40.10.10 Uniformat (Uniformat); Group: RCI 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D4010 - Victaulic-IPS-Elbow No 10-13:Standard:...) | In
1057490 | Nivel 1
1059107 | Nivel 6
1059157 | Nivel 5
1059207 | Nivel 4
1059257 | Nivel 3
1059307 | Nivel 2

# IfcPipeFitting: D4010 - Victaulic-IPS-Reducer No 50-51:Standard (2)
In: Nivel 1
Type - Material: Victaulic
Type - Pset_ManufacturerTypeInformation - Manufacturer: VICTAULIC
Classification: 21.04.40.10.10 Uniformat (Uniformat); Group: RCI 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D4010 - Victaulic-IPS-Reducer No 50-51:Standard:...) | Length (m)
1202557 | 0.028448
1207387 | 0.0174943

# IfcPipeFitting: D4010 - Victaulic-IPS-Rigid Coupling Style 07-W07-107H-N:Standard (39)
Type - Material: Victaulic
Type - Pset_ManufacturerTypeInformation - Manufacturer: VICTAULIC
Classification: 21.04.40.10.10 Uniformat (Uniformat); Group: RCI 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D4010 - Victaulic-IPS-Rigid Coupling Style 07-W07-107H-N:Standard:...) | In
1057430 | Nivel 1
1057456 | Nivel 1
1057492 | Nivel 1
1057494 | Nivel 1
1059109 | Nivel 6
1059111 | Nivel 6
1059123 | Nivel 6
1059125 | Nivel 6
1059133 | Nivel 6
1059159 | Nivel 5
1059161 | Nivel 5
1059173 | Nivel 5
1059175 | Nivel 5
1059183 | Nivel 5
1059209 | Nivel 4
1059211 | Nivel 4
1059223 | Nivel 4
1059225 | Nivel 4
1059233 | Nivel 4
1059259 | Nivel 3
1059261 | Nivel 3
1059273 | Nivel 3
1059275 | Nivel 3
1059283 | Nivel 3
1059309 | Nivel 2
1059311 | Nivel 2
1059323 | Nivel 2
1059325 | Nivel 2
1059331 | Nivel 1
1059333 | Nivel 2
1062548 | Nivel 1
1062550 | Nivel 2
1062552 | Nivel 3
1062554 | Nivel 4
1062556 | Nivel 5
1062558 | Nivel 6
1202561 | Nivel 1
1202563 | Nivel 1
1207389 | Nivel 1

# IfcPipeFitting: D4010 - Victaulic-IPS-Tee-Reducing Tee-No 20-25:Standard (6)
Type - Material: <Unnamed>, Victaulic
Type - Pset_ManufacturerTypeInformation - Manufacturer: VICTAULIC
Classification: 21.04.40.10.10 Uniformat (Uniformat); Group: RCI 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D4010 - Victaulic-IPS-Tee-Reducing Tee-No 20-25:Standard:...) | In
1057426 | Nivel 1
1059113 | Nivel 6
1059163 | Nivel 5
1059213 | Nivel 4
1059263 | Nivel 3
1059313 | Nivel 2

# IfcPipeFitting: D4010- Codo AWWA C900:Standard (2)
In: Nivel 1
Type - Material: <Unnamed>
Classification: 21.04.40.10.10 Uniformat (Uniformat); Group: RCI 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Name (D4010- Codo AWWA C900:Standard:...)
1057097
1057314

# IfcPipeFitting: D4010- Union AWWA C900:Standard, D4010- Union AWWA C900:Standard:1057308
In: Nivel 1
Type - Material: <Unnamed>
Classification: 21.04.40.10.10 Uniformat (Uniformat); Group: RCI 1
Pset_EnvironmentalImpactIndicators - Reference: Standard; sets with these values: 2
Qto_PipeFittingBaseQuantities - Length: 0.0523875 m; GrossCrossSectionArea: 0.00862079 m2; NetCrossSectionArea: 0.00862079 m2; OuterSurfaceArea: 0.0172439 m2

# IfcPipeSegment: Pipe Types:D2010-CPVC.P (360)
Type - PredefinedType: RIGIDSEGMENT
Classification: 21.04.20.10.40 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: D2010-CPVC.P; sets with these values: 2
Qto_PipeSegmentBaseQuantities - GrossCrossSectionArea: 0.000198028 m2; NetCrossSectionArea: 0.000198028 m2
Name (Pipe Types:D2010-CPVC.P:...) | In | InvertElevation (m) | Length (m) | OuterSurfaceArea (m2) | Group
958841 | Nivel 2 | 2.31629 | 0.0940725 | 0.00469314 | AC 1
958851 | Nivel 2 | 2.31629 | 0.925853 | 0.0461894 | AC 1
958861 | Nivel 2 | 2.31629 | 0.570735 | 0.0284731 | AC 1
959232 | Nivel 2 | 2.33296 | 1.10657 | 0.0552052 | AC 1
959240 | Nivel 2 | 3.44379 | 0.0628161 | 0.0031338 | AC 1
963040 | Nivel 2 | 2.33296 | 1.00653 | 0.0502141 | AC 1
963048 | Nivel 2 | 3.34379 | 0.0815263 | 0.00406722 | AC 1
963073 | Nivel 2 | 3.4815 | 0.0685 | 0.00341736 | AC 1
963165 | Nivel 2 | 3.36046 | 0.0580362 | 0.00289534 | AC 1
963329 | Nivel 2 | 3.36051 | 0.21096 | 0.0105245 | AC 1
965121 | Nivel 2 | 2.31629 | 1.8602 | 0.0928028 | AC 1
965238 | Nivel 2 | 2.28296 | 0.0290725 | 0.00145038 | AC 1
965248 | Nivel 2 | 2.26629 | 0.0740725 | 0.00369537 | AC 1
965258 | Nivel 2 | 2.28296 | 0.0290725 | 0.00145038 | AC 1
1063784 | Nivel 2 | 2.31629 | 0.0940725 | 0.00469314 | AC 2
1063786 | Nivel 2 | 2.31629 | 0.168365 | 0.0083995 | AC 2
1063790 | Nivel 2 | 2.31629 | 0.570735 | 0.0284731 | AC 2
1063804 | Nivel 2 | 2.33296 | 1.10657 | 0.0552052 | AC 2
1063806 | Nivel 2 | 3.44379 | 0.0628161 | 0.0031338 | AC 2
1063911 | Nivel 2 | 2.28296 | 1.05653 | 0.0527085 | AC 2
1063913 | Nivel 2 | 3.34379 | 0.0865263 | 0.00431666 | AC 2
1063917 | Nivel 2 | 3.4815 | 0.0685 | 0.00341736 | AC 2
1063920 | Nivel 2 | 3.36046 | 0.0580362 | 0.00289534 | AC 2
1063926 | Nivel 2 | 3.36051 | 0.21346 | 0.0106492 | AC 2
1063933 | Nivel 2 | 2.28296 | 0.0290725 | 0.00145038 | AC 2
1063937 | Nivel 2 | 2.26629 | 1.9552 | 0.0975422 | AC 2
1065521 | Nivel 2 | 2.31629 | 0.0940725 | 0.00469314 | AC 4
1065523 | Nivel 2 | 2.31629 | 0.924073 | 0.0461006 | AC 4
1065527 | Nivel 2 | 2.31629 | 0.570735 | 0.0284731 | AC 4
1065529 | Nivel 2 | 2.33296 | 1.10657 | 0.0552052 | AC 4
1065531 | Nivel 2 | 3.44379 | 0.0628161 | 0.0031338 | AC 4
1065541 | Nivel 2 | 2.33296 | 1.00653 | 0.0502141 | AC 4
1065543 | Nivel 2 | 3.34379 | 0.0865263 | 0.00431666 | AC 4
1065547 | Nivel 2 | 3.4815 | 0.0685 | 0.00341736 | AC 4
1065550 | Nivel 2 | 3.36046 | 0.0580362 | 0.00289534 | AC 4
1065556 | Nivel 2 | 3.36051 | 0.21096 | 0.0105245 | AC 4
1065560 | Nivel 2 | 2.31629 | 1.8602 | 0.0928028 | AC 4
1065562 | Nivel 2 | 2.28296 | 0.0290725 | 0.00145038 | AC 4
1065566 | Nivel 2 | 2.26629 | 0.0740725 | 0.00369537 | AC 4
1065570 | Nivel 2 | 2.28296 | 0.0290725 | 0.00145038 | AC 4
1066084 | Nivel 2 | 2.31629 | 1.08325 | 0.0540418 | AC 2
1066280 | Nivel 2 | 2.28046 | 0.0315725 | 0.0015751 | AC 2
1066290 | Nivel 2 | 2.26379 | 0.0655995 | 0.00327266 | AC 2
1066300 | Nivel 2 | 2.28046 | 0.0315725 | 0.0015751 | AC 2
1066476 | Nivel 2 | 2.31629 | 0.0940725 | 0.00469314 | AC 5
1066478 | Nivel 2 | 2.31629 | 0.168365 | 0.0083995 | AC 5
1066482 | Nivel 2 | 2.31629 | 0.570735 | 0.0284731 | AC 5
1066484 | Nivel 2 | 2.33296 | 1.10657 | 0.0552052 | AC 5
1066486 | Nivel 2 | 3.44379 | 0.0628161 | 0.0031338 | AC 5
1066496 | Nivel 2 | 2.28296 | 1.05653 | 0.0527085 | AC 5
1066498 | Nivel 2 | 3.34379 | 0.0865263 | 0.00431666 | AC 5
1066502 | Nivel 2 | 3.4815 | 0.0685 | 0.00341736 | AC 5
1066505 | Nivel 2 | 3.36046 | 0.0580362 | 0.00289534 | AC 5
1066511 | Nivel 2 | 3.36051 | 0.21096 | 0.0105245 | AC 5
1066515 | Nivel 2 | 2.26629 | 1.9552 | 0.0975422 | AC 5
1066517 | Nivel 2 | 2.28296 | 0.0290725 | 0.00145038 | AC 5
1066531 | Nivel 2 | 2.31629 | 1.04703 | 0.0522346 | AC 5
1066533 | Nivel 2 | 2.28046 | 0.0315725 | 0.0015751 | AC 5
1066537 | Nivel 2 | 2.26379 | 0.0655995 | 0.00327266 | AC 5
1066541 | Nivel 2 | 2.28046 | 0.0315725 | 0.0015751 | AC 5
1106412 | Nivel 1 | -0.03371 | 0.0940725 | 0.00469314 | AC 3
1106414 | Nivel 1 | -0.03371 | 0.919073 | 0.0458511 | AC 3
1106418 | Nivel 1 | -0.03371 | 0.570735 | 0.0284731 | AC 3
1106420 | Nivel 1 | -0.0170363 | 1.10657 | 0.0552052 | AC 3
1106422 | Nivel 1 | 1.09379 | 0.0628161 | 0.0031338 | AC 3
1106432 | Nivel 1 | -0.0170363 | 1.00653 | 0.0502141 | AC 3
1106434 | Nivel 1 | 0.99379 | 0.0865263 | 0.00431666 | AC 3
1106438 | Nivel 1 | 1.1315 | 0.0685 | 0.00341736 | AC 3
1106441 | Nivel 1 | 1.01046 | 0.0580362 | 0.00289534 | AC 3
1106447 | Nivel 1 | 1.01051 | 0.21096 | 0.0105245 | AC 3
1106451 | Nivel 1 | -0.03371 | 1.8602 | 0.0928028 | AC 3
1106453 | Nivel 1 | -0.0670363 | 0.0290725 | 0.00145038 | AC 3
1106457 | Nivel 1 | -0.08371 | 0.0740725 | 0.00369537 | AC 3
1106461 | Nivel 1 | -0.0670363 | 0.0290725 | 0.00145038 | AC 3
1106467 | Nivel 1 | -0.03371 | 0.0940725 | 0.00469314 | AC 8
1106469 | Nivel 1 | -0.03371 | 0.168365 | 0.0083995 | AC 8
1106473 | Nivel 1 | -0.03371 | 0.570735 | 0.0284731 | AC 8
1106475 | Nivel 1 | -0.0170363 | 1.10657 | 0.0552052 | AC 8
1106477 | Nivel 1 | 1.09379 | 0.0628161 | 0.0031338 | AC 8
1106487 | Nivel 1 | -0.0670363 | 1.05653 | 0.0527085 | AC 8
1106489 | Nivel 1 | 0.99379 | 0.0865263 | 0.00431666 | AC 8
1106493 | Nivel 1 | 1.1315 | 0.0685 | 0.00341736 | AC 8
1106496 | Nivel 1 | 1.01046 | 0.0580362 | 0.00289534 | AC 8
1106500 | Nivel 1 | 1.01051 | 0.21096 | 0.0105245 | AC 8
1106504 | Nivel 1 | -0.0670363 | 0.0290725 | 0.00145038 | AC 8
1106508 | Nivel 1 | -0.08371 | 1.9552 | 0.0975422 | AC 8
1106510 | Nivel 1 | -0.03371 | 0.0940725 | 0.00469314 | AC 11
1106512 | Nivel 1 | -0.03371 | 0.919073 | 0.0458511 | AC 11
1106516 | Nivel 1 | -0.03371 | 0.570735 | 0.0284731 | AC 11
1106518 | Nivel 1 | -0.0170363 | 1.10657 | 0.0552052 | AC 11
1106520 | Nivel 1 | 1.09379 | 0.0628161 | 0.0031338 | AC 11
1106530 | Nivel 1 | -0.0170363 | 1.00653 | 0.0502141 | AC 11
1106532 | Nivel 1 | 0.99379 | 0.0865263 | 0.00431666 | AC 11
1106536 | Nivel 1 | 1.1315 | 0.0685 | 0.00341736 | AC 11
1106539 | Nivel 1 | 1.01046 | 0.0580362 | 0.00289534 | AC 11
1106545 | Nivel 1 | 1.01051 | 0.21096 | 0.0105245 | AC 11
1106549 | Nivel 1 | -0.03371 | 1.8602 | 0.0928028 | AC 11
1106551 | Nivel 1 | -0.0670363 | 0.0290725 | 0.00145038 | AC 11
1106555 | Nivel 1 | -0.08371 | 0.0740725 | 0.00369537 | AC 11
1106559 | Nivel 1 | -0.0670363 | 0.0290725 | 0.00145038 | AC 11
1106565 | Nivel 1 | -0.03371 | 1.04653 | 0.0522097 | AC 8
1106567 | Nivel 1 | -0.0695363 | 0.0315725 | 0.0015751 | AC 8
1106571 | Nivel 1 | -0.08621 | 0.0655995 | 0.00327266 | AC 8
1106575 | Nivel 1 | -0.0695363 | 0.0315725 | 0.0015751 | AC 8
1106581 | Nivel 1 | -0.03371 | 0.0940725 | 0.00469314 | AC 14
1106583 | Nivel 1 | -0.03371 | 0.168365 | 0.0083995 | AC 14
1106587 | Nivel 1 | -0.03371 | 0.570735 | 0.0284731 | AC 14
1106589 | Nivel 1 | -0.0170363 | 1.10657 | 0.0552052 | AC 14
1106591 | Nivel 1 | 1.09379 | 0.0628161 | 0.0031338 | AC 14
1106601 | Nivel 1 | -0.0670363 | 1.05653 | 0.0527085 | AC 14
1106603 | Nivel 1 | 0.99379 | 0.0865263 | 0.00431666 | AC 14
1106607 | Nivel 1 | 1.1315 | 0.0685 | 0.00341736 | AC 14
1106610 | Nivel 1 | 1.01046 | 0.0580362 | 0.00289534 | AC 14
1106614 | Nivel 1 | 1.01051 | 0.21096 | 0.0105245 | AC 14
1106618 | Nivel 1 | -0.08371 | 1.9552 | 0.0975422 | AC 14
1106620 | Nivel 1 | -0.0670363 | 0.0290725 | 0.00145038 | AC 14
1106624 | Nivel 1 | -0.03371 | 1.04653 | 0.0522097 | AC 14
1106626 | Nivel 1 | -0.0695363 | 0.0315725 | 0.0015751 | AC 14
1106630 | Nivel 1 | -0.08621 | 0.0655995 | 0.00327266 | AC 14
1106634 | Nivel 1 | -0.0695363 | 0.0315725 | 0.0015751 | AC 14
1113689 | Nivel 3 | 4.66629 | 0.0940725 | 0.00469314 | AC 6
1113691 | Nivel 3 | 4.66629 | 0.925853 | 0.0461894 | AC 6
1113695 | Nivel 3 | 4.66629 | 0.570735 | 0.0284731 | AC 6
1113697 | Nivel 3 | 4.68296 | 1.10657 | 0.0552052 | AC 6
1113699 | Nivel 3 | 5.79379 | 0.0628161 | 0.0031338 | AC 6
1113709 | Nivel 3 | 4.68296 | 1.00653 | 0.0502141 | AC 6
1113711 | Nivel 3 | 5.69379 | 0.0815263 | 0.00406722 | AC 6
1113715 | Nivel 3 | 5.8315 | 0.0685 | 0.00341736 | AC 6
1113718 | Nivel 3 | 5.71046 | 0.0580362 | 0.00289534 | AC 6
1113724 | Nivel 3 | 5.71051 | 0.21096 | 0.0105245 | AC 6
1113728 | Nivel 3 | 4.66629 | 1.8602 | 0.0928028 | AC 6
1113730 | Nivel 3 | 4.63296 | 0.0290725 | 0.00145038 | AC 6
1113734 | Nivel 3 | 4.61629 | 0.0740725 | 0.00369537 | AC 6
1113738 | Nivel 3 | 4.63296 | 0.0290725 | 0.00145038 | AC 6
1113744 | Nivel 3 | 4.66629 | 0.0940725 | 0.00469314 | AC 10
1113746 | Nivel 3 | 4.66629 | 0.168365 | 0.0083995 | AC 10
1113750 | Nivel 3 | 4.66629 | 0.570735 | 0.0284731 | AC 10
1113752 | Nivel 3 | 4.68296 | 1.10657 | 0.0552052 | AC 10
1113754 | Nivel 3 | 5.79379 | 0.0628161 | 0.0031338 | AC 10
1113764 | Nivel 3 | 4.63296 | 1.05653 | 0.0527085 | AC 10
1113766 | Nivel 3 | 5.69379 | 0.0865263 | 0.00431666 | AC 10
1113770 | Nivel 3 | 5.8315 | 0.0685 | 0.00341736 | AC 10
1113773 | Nivel 3 | 5.71046 | 0.0580362 | 0.00289534 | AC 10
1113777 | Nivel 3 | 5.71051 | 0.21096 | 0.0105245 | AC 10
1113781 | Nivel 3 | 4.63296 | 0.0290725 | 0.00145038 | AC 10
1113785 | Nivel 3 | 4.61629 | 1.9552 | 0.0975422 | AC 10
1113787 | Nivel 3 | 4.66629 | 0.0940725 | 0.00469314 | AC 15
1113789 | Nivel 3 | 4.66629 | 0.924073 | 0.0461006 | AC 15
1113793 | Nivel 3 | 4.66629 | 0.570735 | 0.0284731 | AC 15
1113795 | Nivel 3 | 4.68296 | 1.10657 | 0.0552052 | AC 15
1113797 | Nivel 3 | 5.79379 | 0.0628161 | 0.0031338 | AC 15
1113807 | Nivel 3 | 4.68296 | 1.00653 | 0.0502141 | AC 15
1113809 | Nivel 3 | 5.69379 | 0.0865263 | 0.00431666 | AC 15
1113813 | Nivel 3 | 5.8315 | 0.0685 | 0.00341736 | AC 15
1113816 | Nivel 3 | 5.71046 | 0.0580362 | 0.00289534 | AC 15
1113822 | Nivel 3 | 5.71051 | 0.21096 | 0.0105245 | AC 15
1113826 | Nivel 3 | 4.66629 | 1.8602 | 0.0928028 | AC 15
1113828 | Nivel 3 | 4.63296 | 0.0290725 | 0.00145038 | AC 15
1113832 | Nivel 3 | 4.61629 | 0.0740725 | 0.00369537 | AC 15
1113836 | Nivel 3 | 4.63296 | 0.0290725 | 0.00145038 | AC 15
1113842 | Nivel 3 | 4.66629 | 1.08325 | 0.0540418 | AC 10
1113844 | Nivel 3 | 4.63046 | 0.0315725 | 0.0015751 | AC 10
1113848 | Nivel 3 | 4.61379 | 0.0655995 | 0.00327266 | AC 10
1113852 | Nivel 3 | 4.63046 | 0.0315725 | 0.0015751 | AC 10
1113858 | Nivel 3 | 4.66629 | 0.0940725 | 0.00469314 | AC 18
1113860 | Nivel 3 | 4.66629 | 0.168365 | 0.0083995 | AC 18
1113864 | Nivel 3 | 4.66629 | 0.570735 | 0.0284731 | AC 18
1113866 | Nivel 3 | 4.68296 | 1.10657 | 0.0552052 | AC 18
1113868 | Nivel 3 | 5.79379 | 0.0628161 | 0.0031338 | AC 18
1113878 | Nivel 3 | 4.63296 | 1.05653 | 0.0527085 | AC 18
1113880 | Nivel 3 | 5.69379 | 0.0865263 | 0.00431666 | AC 18
1113884 | Nivel 3 | 5.8315 | 0.0685 | 0.00341736 | AC 18
1113887 | Nivel 3 | 5.71046 | 0.0580362 | 0.00289534 | AC 18
1113891 | Nivel 3 | 5.71051 | 0.21096 | 0.0105245 | AC 18
1113895 | Nivel 3 | 4.61629 | 1.9552 | 0.0975422 | AC 18
1113897 | Nivel 3 | 4.63296 | 0.0290725 | 0.00145038 | AC 18
1113901 | Nivel 3 | 4.66629 | 1.04703 | 0.0522346 | AC 18
1113903 | Nivel 3 | 4.63046 | 0.0315725 | 0.0015751 | AC 18
1113907 | Nivel 3 | 4.61379 | 0.0655995 | 0.00327266 | AC 18
1113911 | Nivel 3 | 4.63046 | 0.0315725 | 0.0015751 | AC 18
1114742 | Nivel 4 | 7.01629 | 0.0940725 | 0.00469314 | AC 7
1114744 | Nivel 4 | 7.01629 | 0.925853 | 0.0461894 | AC 7
1114748 | Nivel 4 | 7.01629 | 0.570735 | 0.0284731 | AC 7
1114750 | Nivel 4 | 7.03296 | 1.10657 | 0.0552052 | AC 7
1114752 | Nivel 4 | 8.14379 | 0.0628161 | 0.0031338 | AC 7
1114762 | Nivel 4 | 7.03296 | 1.00653 | 0.0502141 | AC 7
1114764 | Nivel 4 | 8.04379 | 0.0815263 | 0.00406722 | AC 7
1114768 | Nivel 4 | 8.1815 | 0.0685 | 0.00341736 | AC 7
1114771 | Nivel 4 | 8.06046 | 0.0580362 | 0.00289534 | AC 7
1114777 | Nivel 4 | 8.06051 | 0.21096 | 0.0105245 | AC 7
1114781 | Nivel 4 | 7.01629 | 1.8602 | 0.0928028 | AC 7
1114783 | Nivel 4 | 6.98296 | 0.0290725 | 0.00145038 | AC 7
1114787 | Nivel 4 | 6.96629 | 0.0740725 | 0.00369537 | AC 7
1114791 | Nivel 4 | 6.98296 | 0.0290725 | 0.00145038 | AC 7
1114797 | Nivel 4 | 7.01629 | 0.0940725 | 0.00469314 | AC 13
1114799 | Nivel 4 | 7.01629 | 0.168365 | 0.0083995 | AC 13
1114803 | Nivel 4 | 7.01629 | 0.570735 | 0.0284731 | AC 13
1114805 | Nivel 4 | 7.03296 | 1.10657 | 0.0552052 | AC 13
1114807 | Nivel 4 | 8.14379 | 0.0628161 | 0.0031338 | AC 13
1114817 | Nivel 4 | 6.98296 | 1.05653 | 0.0527085 | AC 13
1114819 | Nivel 4 | 8.04379 | 0.0865263 | 0.00431666 | AC 13
1114823 | Nivel 4 | 8.1815 | 0.0685 | 0.00341736 | AC 13
1114826 | Nivel 4 | 8.06046 | 0.0580362 | 0.00289534 | AC 13
1114830 | Nivel 4 | 8.06051 | 0.21096 | 0.0105245 | AC 13
1114834 | Nivel 4 | 6.98296 | 0.0290725 | 0.00145038 | AC 13
1114838 | Nivel 4 | 6.96629 | 1.9552 | 0.0975422 | AC 13
1114840 | Nivel 4 | 7.01629 | 0.0940725 | 0.00469314 | AC 19
1114842 | Nivel 4 | 7.01629 | 0.924073 | 0.0461006 | AC 19
1114846 | Nivel 4 | 7.01629 | 0.570735 | 0.0284731 | AC 19
1114848 | Nivel 4 | 7.03296 | 1.10657 | 0.0552052 | AC 19
1114850 | Nivel 4 | 8.14379 | 0.0628161 | 0.0031338 | AC 19
1114860 | Nivel 4 | 7.03296 | 1.00653 | 0.0502141 | AC 19
1114862 | Nivel 4 | 8.04379 | 0.0865263 | 0.00431666 | AC 19
1114866 | Nivel 4 | 8.1815 | 0.0685 | 0.00341736 | AC 19
1114869 | Nivel 4 | 8.06046 | 0.0580362 | 0.00289534 | AC 19
1114875 | Nivel 4 | 8.06051 | 0.21096 | 0.0105245 | AC 19
1114879 | Nivel 4 | 7.01629 | 1.8602 | 0.0928028 | AC 19
1114881 | Nivel 4 | 6.98296 | 0.0290725 | 0.00145038 | AC 19
1114885 | Nivel 4 | 6.96629 | 0.0740725 | 0.00369537 | AC 19
1114889 | Nivel 4 | 6.98296 | 0.0290725 | 0.00145038 | AC 19
1114895 | Nivel 4 | 7.01629 | 1.08325 | 0.0540418 | AC 13
1114897 | Nivel 4 | 6.98046 | 0.0315725 | 0.0015751 | AC 13
1114901 | Nivel 4 | 6.96379 | 0.0655995 | 0.00327266 | AC 13
1114905 | Nivel 4 | 6.98046 | 0.0315725 | 0.0015751 | AC 13
1114911 | Nivel 4 | 7.01629 | 0.0940725 | 0.00469314 | AC 22
1114913 | Nivel 4 | 7.01629 | 0.168365 | 0.0083995 | AC 22
1114917 | Nivel 4 | 7.01629 | 0.570735 | 0.0284731 | AC 22
1114919 | Nivel 4 | 7.03296 | 1.10657 | 0.0552052 | AC 22
1114921 | Nivel 4 | 8.14379 | 0.0628161 | 0.0031338 | AC 22
1114931 | Nivel 4 | 6.98296 | 1.05653 | 0.0527085 | AC 22
1114933 | Nivel 4 | 8.04379 | 0.0865263 | 0.00431666 | AC 22
1114937 | Nivel 4 | 8.1815 | 0.0685 | 0.00341736 | AC 22
1114940 | Nivel 4 | 8.06046 | 0.0580362 | 0.00289534 | AC 22
1114944 | Nivel 4 | 8.06051 | 0.21096 | 0.0105245 | AC 22
1114948 | Nivel 4 | 6.96629 | 1.9552 | 0.0975422 | AC 22
1114950 | Nivel 4 | 6.98296 | 0.0290725 | 0.00145038 | AC 22
1114954 | Nivel 4 | 7.01629 | 1.04703 | 0.0522346 | AC 22
1114956 | Nivel 4 | 6.98046 | 0.0315725 | 0.0015751 | AC 22
1114960 | Nivel 4 | 6.96379 | 0.0655995 | 0.00327266 | AC 22
1114964 | Nivel 4 | 6.98046 | 0.0315725 | 0.0015751 | AC 22
1115795 | Nivel 5 | 9.36629 | 0.0940725 | 0.00469314 | AC 9
1115797 | Nivel 5 | 9.36629 | 0.925853 | 0.0461894 | AC 9
1115801 | Nivel 5 | 9.36629 | 0.570735 | 0.0284731 | AC 9
1115803 | Nivel 5 | 9.38296 | 1.10657 | 0.0552052 | AC 9
1115805 | Nivel 5 | 10.4938 | 0.0628161 | 0.0031338 | AC 9
1115815 | Nivel 5 | 9.38296 | 1.00653 | 0.0502141 | AC 9
1115817 | Nivel 5 | 10.3938 | 0.0815263 | 0.00406722 | AC 9
1115821 | Nivel 5 | 10.5315 | 0.0685 | 0.00341736 | AC 9
1115824 | Nivel 5 | 10.4105 | 0.0580362 | 0.00289534 | AC 9
1115830 | Nivel 5 | 10.4105 | 0.21096 | 0.0105245 | AC 9
1115834 | Nivel 5 | 9.36629 | 1.8602 | 0.0928028 | AC 9
1115836 | Nivel 5 | 9.33296 | 0.0290725 | 0.00145038 | AC 9
1115840 | Nivel 5 | 9.31629 | 0.0740725 | 0.00369537 | AC 9
1115844 | Nivel 5 | 9.33296 | 0.0290725 | 0.00145038 | AC 9
1115850 | Nivel 5 | 9.36629 | 0.0940725 | 0.00469314 | AC 17
1115852 | Nivel 5 | 9.36629 | 0.168365 | 0.0083995 | AC 17
1115856 | Nivel 5 | 9.36629 | 0.570735 | 0.0284731 | AC 17
1115858 | Nivel 5 | 9.38296 | 1.10657 | 0.0552052 | AC 17
1115860 | Nivel 5 | 10.4938 | 0.0628161 | 0.0031338 | AC 17
1115870 | Nivel 5 | 9.33296 | 1.05653 | 0.0527085 | AC 17
1115872 | Nivel 5 | 10.3938 | 0.0865263 | 0.00431666 | AC 17
1115876 | Nivel 5 | 10.5315 | 0.0685 | 0.00341736 | AC 17
1115879 | Nivel 5 | 10.4105 | 0.0580362 | 0.00289534 | AC 17
1115883 | Nivel 5 | 10.4105 | 0.21096 | 0.0105245 | AC 17
1115887 | Nivel 5 | 9.33296 | 0.0290725 | 0.00145038 | AC 17
1115891 | Nivel 5 | 9.31629 | 1.9552 | 0.0975422 | AC 17
1115893 | Nivel 5 | 9.36629 | 0.0940725 | 0.00469314 | AC 23
1115895 | Nivel 5 | 9.36629 | 0.924073 | 0.0461006 | AC 23
1115899 | Nivel 5 | 9.36629 | 0.570735 | 0.0284731 | AC 23
1115901 | Nivel 5 | 9.38296 | 1.10657 | 0.0552052 | AC 23
1115903 | Nivel 5 | 10.4938 | 0.0628161 | 0.0031338 | AC 23
1115913 | Nivel 5 | 9.38296 | 1.00653 | 0.0502141 | AC 23
1115915 | Nivel 5 | 10.3938 | 0.0865263 | 0.00431666 | AC 23
1115919 | Nivel 5 | 10.5315 | 0.0685 | 0.00341736 | AC 23
1115922 | Nivel 5 | 10.4105 | 0.0580362 | 0.00289534 | AC 23
1115928 | Nivel 5 | 10.4105 | 0.21096 | 0.0105245 | AC 23
1115932 | Nivel 5 | 9.36629 | 1.8602 | 0.0928028 | AC 23
1115934 | Nivel 5 | 9.33296 | 0.0290725 | 0.00145038 | AC 23
1115938 | Nivel 5 | 9.31629 | 0.0740725 | 0.00369537 | AC 23
1115942 | Nivel 5 | 9.33296 | 0.0290725 | 0.00145038 | AC 23
1115948 | Nivel 5 | 9.36629 | 1.08325 | 0.0540418 | AC 17
1115950 | Nivel 5 | 9.33046 | 0.0315725 | 0.0015751 | AC 17
1115954 | Nivel 5 | 9.31379 | 0.0655995 | 0.00327266 | AC 17
1115958 | Nivel 5 | 9.33046 | 0.0315725 | 0.0015751 | AC 17
1115964 | Nivel 5 | 9.36629 | 0.0940725 | 0.00469314 | AC 26
1115966 | Nivel 5 | 9.36629 | 0.168365 | 0.0083995 | AC 26
1115970 | Nivel 5 | 9.36629 | 0.570735 | 0.0284731 | AC 26
1115972 | Nivel 5 | 9.38296 | 1.10657 | 0.0552052 | AC 26
1115974 | Nivel 5 | 10.4938 | 0.0628161 | 0.0031338 | AC 26
1115984 | Nivel 5 | 9.33296 | 1.05653 | 0.0527085 | AC 26
1115986 | Nivel 5 | 10.3938 | 0.0865263 | 0.00431666 | AC 26
1115990 | Nivel 5 | 10.5315 | 0.0685 | 0.00341736 | AC 26
1115993 | Nivel 5 | 10.4105 | 0.0580362 | 0.00289534 | AC 26
1115997 | Nivel 5 | 10.4105 | 0.21096 | 0.0105245 | AC 26
1116001 | Nivel 5 | 9.31629 | 1.9552 | 0.0975422 | AC 26
1116003 | Nivel 5 | 9.33296 | 0.0290725 | 0.00145038 | AC 26
1116007 | Nivel 5 | 9.36629 | 1.04703 | 0.0522346 | AC 26
1116009 | Nivel 5 | 9.33046 | 0.0315725 | 0.0015751 | AC 26
1116013 | Nivel 5 | 9.31379 | 0.0655995 | 0.00327266 | AC 26
1116017 | Nivel 5 | 9.33046 | 0.0315725 | 0.0015751 | AC 26
1116836 | Nivel 6 | 11.7163 | 0.0940725 | 0.00469314 | AC 12
1116838 | Nivel 6 | 11.7163 | 0.925853 | 0.0461894 | AC 12
1116842 | Nivel 6 | 11.7163 | 0.570735 | 0.0284731 | AC 12
1116844 | Nivel 6 | 11.733 | 1.10657 | 0.0552052 | AC 12
1116846 | Nivel 6 | 12.8438 | 0.0628161 | 0.0031338 | AC 12
1116856 | Nivel 6 | 11.733 | 1.00653 | 0.0502141 | AC 12
1116858 | Nivel 6 | 12.7438 | 0.0815263 | 0.00406722 | AC 12
1116862 | Nivel 6 | 12.8815 | 0.0685 | 0.00341736 | AC 12
1116865 | Nivel 6 | 12.7605 | 0.0580362 | 0.00289534 | AC 12
1116871 | Nivel 6 | 12.7605 | 0.21096 | 0.0105245 | AC 12
1116875 | Nivel 6 | 11.7163 | 1.8602 | 0.0928028 | AC 12
1116877 | Nivel 6 | 11.683 | 0.0290725 | 0.00145038 | AC 12
1116881 | Nivel 6 | 11.6663 | 0.0740725 | 0.00369537 | AC 12
1116885 | Nivel 6 | 11.683 | 0.0290725 | 0.00145038 | AC 12
1116891 | Nivel 6 | 11.7163 | 0.0940725 | 0.00469314 | AC 21
1116893 | Nivel 6 | 11.7163 | 0.168365 | 0.0083995 | AC 21
1116897 | Nivel 6 | 11.7163 | 0.570735 | 0.0284731 | AC 21
1116899 | Nivel 6 | 11.733 | 1.10657 | 0.0552052 | AC 21
1116901 | Nivel 6 | 12.8438 | 0.0628161 | 0.0031338 | AC 21
1116911 | Nivel 6 | 11.683 | 1.05653 | 0.0527085 | AC 21
1116913 | Nivel 6 | 12.7438 | 0.0865263 | 0.00431666 | AC 21
1116917 | Nivel 6 | 12.8815 | 0.0685 | 0.00341736 | AC 21
1116920 | Nivel 6 | 12.7605 | 0.0580362 | 0.00289534 | AC 21
1116924 | Nivel 6 | 12.7605 | 0.21096 | 0.0105245 | AC 21
1116928 | Nivel 6 | 11.683 | 0.0290725 | 0.00145038 | AC 21
1116932 | Nivel 6 | 11.6663 | 1.9552 | 0.0975422 | AC 21
1116934 | Nivel 6 | 11.7163 | 0.0940725 | 0.00469314 | AC 27
1116936 | Nivel 6 | 11.7163 | 0.924073 | 0.0461006 | AC 27
1116940 | Nivel 6 | 11.7163 | 0.570735 | 0.0284731 | AC 27
1116942 | Nivel 6 | 11.733 | 1.10657 | 0.0552052 | AC 27
1116944 | Nivel 6 | 12.8438 | 0.0628161 | 0.0031338 | AC 27
1116954 | Nivel 6 | 11.733 | 1.00653 | 0.0502141 | AC 27
1116956 | Nivel 6 | 12.7438 | 0.0865263 | 0.00431666 | AC 27
1116960 | Nivel 6 | 12.8815 | 0.0685 | 0.00341736 | AC 27
1116963 | Nivel 6 | 12.7605 | 0.0580362 | 0.00289534 | AC 27
1116969 | Nivel 6 | 12.7605 | 0.21096 | 0.0105245 | AC 27
1116973 | Nivel 6 | 11.7163 | 1.8602 | 0.0928028 | AC 27
1116975 | Nivel 6 | 11.683 | 0.0290725 | 0.00145038 | AC 27
1116979 | Nivel 6 | 11.6663 | 0.0740725 | 0.00369537 | AC 27
1116983 | Nivel 6 | 11.683 | 0.0290725 | 0.00145038 | AC 27
1116989 | Nivel 6 | 11.7163 | 1.08325 | 0.0540418 | AC 21
1116991 | Nivel 6 | 11.6805 | 0.0315725 | 0.0015751 | AC 21
1116995 | Nivel 6 | 11.6638 | 0.0655995 | 0.00327266 | AC 21
1116999 | Nivel 6 | 11.6805 | 0.0315725 | 0.0015751 | AC 21
1117005 | Nivel 6 | 11.7163 | 0.0940725 | 0.00469314 | AC 30
1117007 | Nivel 6 | 11.7163 | 0.168365 | 0.0083995 | AC 30
1117011 | Nivel 6 | 11.7163 | 0.570735 | 0.0284731 | AC 30
1117013 | Nivel 6 | 11.733 | 1.10657 | 0.0552052 | AC 30
1117015 | Nivel 6 | 12.8438 | 0.0628161 | 0.0031338 | AC 30
1117025 | Nivel 6 | 11.683 | 1.05653 | 0.0527085 | AC 30
1117027 | Nivel 6 | 12.7438 | 0.0865263 | 0.00431666 | AC 30
1117031 | Nivel 6 | 12.8815 | 0.0685 | 0.00341736 | AC 30
1117034 | Nivel 6 | 12.7605 | 0.0580362 | 0.00289534 | AC 30
1117038 | Nivel 6 | 12.7605 | 0.21096 | 0.0105245 | AC 30
1117042 | Nivel 6 | 11.6663 | 1.9552 | 0.0975422 | AC 30
1117044 | Nivel 6 | 11.683 | 0.0290725 | 0.00145038 | AC 30
1117048 | Nivel 6 | 11.7163 | 1.04703 | 0.0522346 | AC 30
1117050 | Nivel 6 | 11.6805 | 0.0315725 | 0.0015751 | AC 30
1117054 | Nivel 6 | 11.6638 | 0.0655995 | 0.00327266 | AC 30
1117058 | Nivel 6 | 11.6805 | 0.0315725 | 0.0015751 | AC 30

# IfcPipeSegment: Pipe Types:D2010-PVC.F (2)
In: Nivel 1
Type - PredefinedType: RIGIDSEGMENT
Classification: 21.04.40.10.10 Uniformat (Uniformat); Group: RCI 1
Pset_EnvironmentalImpactIndicators - Reference: D2010-PVC.F; sets with these values: 2
Qto_PipeSegmentBaseQuantities - GrossCrossSectionArea: 0.000876027 m2; NetCrossSectionArea: 0.000876027 m2
Name (Pipe Types:D2010-PVC.F:...) | InvertElevation (m) | Length (m) | OuterSurfaceArea (m2)
1207404 | 14.7949 | 0.087894 | 0.00922265
1208327 | 14.401 | 0.324147 | 0.0340125

# IfcPipeSegment: Pipe Types:D2010-PVC.P (1097)
Type - PredefinedType: RIGIDSEGMENT
Classification: 21.04.20.10.40 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: D2010-PVC.P; sets with these values: 2
Name (Pipe Types:D2010-PVC.P:...) | In | InvertElevation (m) | Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Group
1055047 | Nivel 1 | -0.704175 | 4.99923 | 0.00418476 | 1.1465 | AF 2
1055057 | Nivel 1 | -0.704175 | 1.32845 | 0.00418476 | 0.304662 | AF 2
1056338 | Nivel 1 | 14.6115 | 0.046371 | 0.000357613 | 0.00310879 | AF 2
1061057 | Nivel 1 | 0.348485 | 0.095 | 0.000876027 | 0.00996827 | AF 2
1061066 | Nivel 1 | 0.2566 | 0.0661751 | 0.00418476 | 0.0151763 | AF 2
1061138 | Nivel 2 | 2.69849 | 0.103134 | 0.000876027 | 0.0108218 | AF 2
1061149 | Nivel 3 | 5.04849 | 0.103134 | 0.000876027 | 0.0108218 | AF 2
1061160 | Nivel 4 | 7.39849 | 0.111208 | 0.000876027 | 0.011669 | AF 2
1061171 | Nivel 5 | 9.74849 | 0.1163 | 0.000876027 | 0.0122033 | AF 2
1061182 | Nivel 6 | 12.0985 | 0.1163 | 0.000876027 | 0.0122033 | AF 2
1061212 | Nivel 1 | 9.78483 | 2.3058 | 0.00139846 | 0.305692 | AF 2
1061262 | Nivel 1 | 7.44407 | 2.29656 | 0.00139846 | 0.304467 | AF 2
1061285 | Nivel 1 | 5.10214 | 2.28413 | 0.00183197 | 0.346592 | AF 2
1061343 | Nivel 1 | 2.74578 | 2.2839 | 0.00285535 | 0.432658 | AF 2
1061387 | Nivel 1 | 0.410275 | 2.2694 | 0.00285535 | 0.429911 | AF 2
1110016 | Nivel 2 | 2.299 | 1.74591 | 0.000558561 | 0.146283 | AF 1
1110020 | Nivel 2 | 2.30162 | 0.768034 | 0.000357613 | 0.0514902 | AF 1
1110025 | Nivel 2 | 2.29901 | 0.928204 | 0.000558561 | 0.0777708 | AF 1
1110028 | Nivel 2 | 2.30162 | 0.591494 | 0.000357613 | 0.0396547 | AF 1
1110030 | Nivel 2 | 2.30162 | 0.380489 | 0.000357613 | 0.0255086 | AF 1
1110034 | Nivel 2 | 2.30162 | 0.363669 | 0.000357613 | 0.0243809 | AF 1
1110037 | Nivel 2 | 2.29901 | 1.76723 | 0.000558561 | 0.148069 | AF 1
1110040 | Nivel 2 | 2.30162 | 0.313599 | 0.000357613 | 0.0210242 | AF 1
1110044 | Nivel 2 | 2.30162 | 0.315695 | 0.000357613 | 0.0211647 | AF 1
1110047 | Nivel 2 | 2.30162 | 0.104017 | 0.000357613 | 0.00697349 | AF 1
1110050 | Nivel 2 | 2.30162 | 0.871288 | 0.000357613 | 0.0584126 | AF 1
1110052 | Nivel 2 | 2.30162 | 0.9356 | 0.000357613 | 0.0627241 | AF 1
1110054 | Nivel 2 | 2.30162 | 0.478762 | 0.000357613 | 0.032097 | AF 1
1110058 | Nivel 2 | 2.30162 | 0.753174 | 0.000357613 | 0.050494 | AF 1
1110062 | Nivel 2 | 2.30162 | 0.256956 | 0.000357613 | 0.0172268 | AF 1
1110064 | Nivel 2 | 2.30162 | 0.481997 | 0.000357613 | 0.0323138 | AF 1
1110070 | Nivel 2 | 2.32296 | 1.11399 | 0.000357613 | 0.0746839 | AF 1
1110072 | Nivel 2 | 3.4417 | 0.0776598 | 0.000357613 | 0.00520644 | AF 1
1110078 | Nivel 2 | 2.30162 | 0.741455 | 0.000357613 | 0.0497083 | AF 1
1110082 | Nivel 2 | 2.32296 | 0.264838 | 0.000357613 | 0.0177551 | AF 1
1110084 | Nivel 2 | 2.5917 | 0.0690775 | 0.000357613 | 0.00463107 | AF 1
1110090 | Nivel 2 | 2.6122 | 0.216278 | 0.000357613 | 0.0144996 | AF 1
1110096 | Nivel 2 | 2.32296 | 0.517438 | 0.000357613 | 0.0346898 | AF 1
1110098 | Nivel 2 | 2.8443 | 0.0640775 | 0.000357613 | 0.00429586 | AF 1
1110104 | Nivel 2 | 2.8648 | 0.216278 | 0.000357613 | 0.0144996 | AF 1
1110110 | Nivel 2 | 2.32296 | 0.914838 | 0.000357613 | 0.0613322 | AF 1
1110112 | Nivel 2 | 3.2417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 1
1110118 | Nivel 2 | 3.2622 | 0.216278 | 0.000357613 | 0.0144996 | AF 1
1110122 | Nivel 2 | 2.32296 | 0.714838 | 0.000357613 | 0.0479238 | AF 1
1110124 | Nivel 2 | 3.0417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 1
1110130 | Nivel 2 | 3.0622 | 0.216278 | 0.000357613 | 0.0144996 | AF 1
1110140 | Nivel 2 | 2.32296 | 0.614838 | 0.000357613 | 0.0412197 | AF 1
1110142 | Nivel 2 | 2.9417 | 0.0540775 | 0.000357613 | 0.00362544 | AF 1
1110148 | Nivel 2 | 2.9622 | 0.216278 | 0.000357613 | 0.0144996 | AF 1
1110156 | Nivel 2 | 2.32296 | 1.01484 | 0.000357613 | 0.0680363 | AF 1
1110158 | Nivel 2 | 3.3417 | 0.0760338 | 0.000357613 | 0.00509742 | AF 1
1110162 | Nivel 2 | 3.3622 | 0.191278 | 0.000357613 | 0.0128235 | AF 1
1110166 | Nivel 2 | 3.36304 | 0.0554563 | 0.000357613 | 0.00371788 | AF 1
1110171 | Nivel 2 | 3.4815 | 0.0685 | 0.000357613 | 0.00459235 | AF 1
1110173 | Nivel 2 | 2.29901 | 0.653703 | 0.000558561 | 0.0547713 | AF 16
1110175 | Nivel 2 | 2.29901 | 1.97091 | 0.000558561 | 0.165135 | AF 16
1110179 | Nivel 2 | 2.30162 | 0.75842 | 0.000357613 | 0.0508457 | AF 16
1110184 | Nivel 2 | 2.29901 | 0.937817 | 0.000558561 | 0.0785762 | AF 16
1110187 | Nivel 2 | 2.30162 | 0.464183 | 0.000357613 | 0.0311195 | AF 16
1110189 | Nivel 2 | 2.30162 | 0.499293 | 0.000357613 | 0.0334734 | AF 16
1110193 | Nivel 2 | 2.30162 | 0.529611 | 0.000357613 | 0.0355059 | AF 16
1110196 | Nivel 2 | 2.29901 | 1.66954 | 0.000558561 | 0.139884 | AF 16
1110199 | Nivel 2 | 2.30162 | 0.313599 | 0.000357613 | 0.0210242 | AF 16
1110203 | Nivel 2 | 2.30162 | 0.213913 | 0.000357613 | 0.014341 | AF 16
1110205 | Nivel 2 | 2.30162 | 0.77535 | 0.000357613 | 0.0519807 | AF 16
1110207 | Nivel 2 | 2.30162 | 0.664404 | 0.000357613 | 0.0445427 | AF 16
1110209 | Nivel 2 | 2.30162 | 0.483762 | 0.000357613 | 0.0324322 | AF 16
1110213 | Nivel 2 | 2.30162 | 0.791537 | 0.000357613 | 0.0530659 | AF 16
1110217 | Nivel 2 | 2.30162 | 0.0618916 | 0.000357613 | 0.00414931 | AF 16
1110219 | Nivel 2 | 2.30162 | 0.486997 | 0.000357613 | 0.0326491 | AF 16
1110225 | Nivel 2 | 2.32296 | 1.11399 | 0.000357613 | 0.0746839 | AF 16
1110227 | Nivel 2 | 3.4417 | 0.0776598 | 0.000357613 | 0.00520644 | AF 16
1110233 | Nivel 2 | 2.30162 | 0.736455 | 0.000357613 | 0.0493731 | AF 16
1110237 | Nivel 2 | 2.32296 | 0.264838 | 0.000357613 | 0.0177551 | AF 16
1110239 | Nivel 2 | 2.5917 | 0.0690775 | 0.000357613 | 0.00463107 | AF 16
1110245 | Nivel 2 | 2.6122 | 0.216278 | 0.000357613 | 0.0144996 | AF 16
1110251 | Nivel 2 | 2.32296 | 0.517438 | 0.000357613 | 0.0346898 | AF 16
1110253 | Nivel 2 | 2.8443 | 0.0640775 | 0.000357613 | 0.00429586 | AF 16
1110259 | Nivel 2 | 2.8648 | 0.216278 | 0.000357613 | 0.0144996 | AF 16
1110265 | Nivel 2 | 2.32296 | 0.914838 | 0.000357613 | 0.0613322 | AF 16
1110267 | Nivel 2 | 3.2417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 16
1110273 | Nivel 2 | 3.2622 | 0.216278 | 0.000357613 | 0.0144996 | AF 16
1110277 | Nivel 2 | 2.32296 | 0.714838 | 0.000357613 | 0.0479238 | AF 16
1110279 | Nivel 2 | 3.0417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 16
1110285 | Nivel 2 | 3.0622 | 0.216278 | 0.000357613 | 0.0144996 | AF 16
1110295 | Nivel 2 | 2.32296 | 0.614838 | 0.000357613 | 0.0412197 | AF 16
1110297 | Nivel 2 | 2.9417 | 0.0540775 | 0.000357613 | 0.00362544 | AF 16
1110303 | Nivel 2 | 2.9622 | 0.216278 | 0.000357613 | 0.0144996 | AF 16
1110311 | Nivel 2 | 2.32296 | 1.01484 | 0.000357613 | 0.0680363 | AF 16
1110313 | Nivel 2 | 3.3417 | 0.0760338 | 0.000357613 | 0.00509742 | AF 16
1110317 | Nivel 2 | 3.3622 | 0.216278 | 0.000357613 | 0.0144996 | AF 16
1110321 | Nivel 2 | 3.36304 | 0.0554562 | 0.000357613 | 0.00371788 | AF 16
1110326 | Nivel 2 | 3.4815 | 0.0685 | 0.000357613 | 0.00459235 | AF 16
1110330 | Nivel 2 | 2.30162 | 0.241519 | 0.000357613 | 0.0161918 | AF 16
1110333 | Nivel 2 | 2.30162 | 0.0765385 | 0.000357613 | 0.00513126 | AF 16
1110338 | Nivel 2 | 2.29964 | 0.613703 | 0.000558561 | 0.0514198 | AF 30
1110340 | Nivel 2 | 2.29964 | 1.73606 | 0.000558561 | 0.145458 | AF 30
1110344 | Nivel 2 | 2.30224 | 0.888034 | 0.000357613 | 0.0595352 | AF 30
1110349 | Nivel 2 | 2.29964 | 0.808204 | 0.000558561 | 0.0677164 | AF 30
1110352 | Nivel 2 | 2.30224 | 0.727325 | 0.000357613 | 0.048761 | AF 30
1110354 | Nivel 2 | 2.30224 | 0.494691 | 0.000357613 | 0.0331649 | AF 30
1110358 | Nivel 2 | 2.30224 | 0.447444 | 0.000357613 | 0.0299973 | AF 30
1110361 | Nivel 2 | 2.29964 | 1.6314 | 0.000558561 | 0.136689 | AF 30
1110364 | Nivel 2 | 2.30224 | 0.313599 | 0.000357613 | 0.0210242 | AF 30
1110368 | Nivel 2 | 2.30224 | 0.315695 | 0.000357613 | 0.0211647 | AF 30
1110371 | Nivel 2 | 2.30224 | 0.109815 | 0.000357613 | 0.0073622 | AF 30
1110374 | Nivel 2 | 2.30224 | 0.876288 | 0.000357613 | 0.0587478 | AF 30
1110376 | Nivel 2 | 2.30224 | 1.0556 | 0.000357613 | 0.0707691 | AF 30
1110378 | Nivel 2 | 2.30224 | 0.483762 | 0.000357613 | 0.0324322 | AF 30
1110382 | Nivel 2 | 2.30224 | 0.753174 | 0.000357613 | 0.050494 | AF 30
1110386 | Nivel 2 | 2.30224 | 0.136956 | 0.000357613 | 0.00918176 | AF 30
1110388 | Nivel 2 | 2.30224 | 0.486997 | 0.000357613 | 0.0326491 | AF 30
1110394 | Nivel 2 | 2.32359 | 1.11337 | 0.000357613 | 0.074642 | AF 30
1110396 | Nivel 2 | 3.4417 | 0.0676598 | 0.000357613 | 0.00453602 | AF 30
1110402 | Nivel 2 | 2.30224 | 0.726455 | 0.000357613 | 0.0487027 | AF 30
1110406 | Nivel 2 | 2.32359 | 0.264213 | 0.000357613 | 0.0177132 | AF 30
1110408 | Nivel 2 | 2.5917 | 0.0690775 | 0.000357613 | 0.00463107 | AF 30
1110414 | Nivel 2 | 2.6122 | 0.216278 | 0.000357613 | 0.0144996 | AF 30
1110420 | Nivel 2 | 2.32359 | 0.516813 | 0.000357613 | 0.0346479 | AF 30
1110422 | Nivel 2 | 2.8443 | 0.0640775 | 0.000357613 | 0.00429586 | AF 30
1110428 | Nivel 2 | 2.8648 | 0.216278 | 0.000357613 | 0.0144996 | AF 30
1110434 | Nivel 2 | 2.32359 | 0.914213 | 0.000357613 | 0.0612903 | AF 30
1110436 | Nivel 2 | 3.2417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 30
1110442 | Nivel 2 | 3.2622 | 0.216278 | 0.000357613 | 0.0144996 | AF 30
1110446 | Nivel 2 | 2.32359 | 0.714213 | 0.000357613 | 0.0478819 | AF 30
1110448 | Nivel 2 | 3.0417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 30
1110454 | Nivel 2 | 3.0622 | 0.216278 | 0.000357613 | 0.0144996 | AF 30
1110464 | Nivel 2 | 2.32359 | 0.614213 | 0.000357613 | 0.0411778 | AF 30
1110466 | Nivel 2 | 2.9417 | 0.0540775 | 0.000357613 | 0.00362544 | AF 30
1110472 | Nivel 2 | 2.9622 | 0.216278 | 0.000357613 | 0.0144996 | AF 30
1110480 | Nivel 2 | 2.32359 | 1.01421 | 0.000357613 | 0.0679944 | AF 30
1110482 | Nivel 2 | 3.3417 | 0.0760338 | 0.000357613 | 0.00509742 | AF 30
1110486 | Nivel 2 | 3.3622 | 0.191278 | 0.000357613 | 0.0128235 | AF 30
1110490 | Nivel 2 | 3.36304 | 0.0554563 | 0.000357613 | 0.00371788 | AF 30
1110495 | Nivel 2 | 3.4815 | 0.0685 | 0.000357613 | 0.00459235 | AF 30
1110499 | Nivel 2 | 2.2992 | 1.18468 | 0.000558561 | 0.0992597 | AF 44
1110501 | Nivel 2 | 2.2992 | 1.96111 | 0.000558561 | 0.164314 | AF 44
1110505 | Nivel 2 | 2.30181 | 0.75886 | 0.000357613 | 0.0508752 | AF 44
1110510 | Nivel 2 | 2.2992 | 0.937378 | 0.000558561 | 0.0785394 | AF 44
1110513 | Nivel 2 | 2.30181 | 0.439182 | 0.000357613 | 0.0294434 | AF 44
1110515 | Nivel 2 | 2.30181 | 0.499732 | 0.000357613 | 0.0335028 | AF 44
1110519 | Nivel 2 | 2.30181 | 0.52827 | 0.000357613 | 0.035416 | AF 44
1110522 | Nivel 2 | 2.2992 | 1.69454 | 0.000558561 | 0.141979 | AF 44
1110525 | Nivel 2 | 2.30181 | 0.313599 | 0.000357613 | 0.0210242 | AF 44
1110529 | Nivel 2 | 2.30181 | 0.213913 | 0.000357613 | 0.014341 | AF 44
1110531 | Nivel 2 | 2.30181 | 0.77535 | 0.000357613 | 0.0519807 | AF 44
1110533 | Nivel 2 | 2.30181 | 0.701569 | 0.000357613 | 0.0470343 | AF 44
1110535 | Nivel 2 | 2.30181 | 0.483762 | 0.000357613 | 0.0324322 | AF 44
1110539 | Nivel 2 | 2.30181 | 0.754811 | 0.000357613 | 0.0506038 | AF 44
1110543 | Nivel 2 | 2.30181 | 0.124303 | 0.000357613 | 0.0083335 | AF 44
1110545 | Nivel 2 | 2.30181 | 0.486997 | 0.000357613 | 0.0326491 | AF 44
1110551 | Nivel 2 | 2.32315 | 1.11381 | 0.000357613 | 0.0746713 | AF 44
1110553 | Nivel 2 | 3.4417 | 0.0676598 | 0.000357613 | 0.00453602 | AF 44
1110559 | Nivel 2 | 2.30181 | 0.726455 | 0.000357613 | 0.0487027 | AF 44
1110563 | Nivel 2 | 2.32315 | 0.264649 | 0.000357613 | 0.0177425 | AF 44
1110565 | Nivel 2 | 2.5917 | 0.0690775 | 0.000357613 | 0.00463107 | AF 44
1110571 | Nivel 2 | 2.6122 | 0.216278 | 0.000357613 | 0.0144996 | AF 44
1110577 | Nivel 2 | 2.32315 | 0.517249 | 0.000357613 | 0.0346772 | AF 44
1110579 | Nivel 2 | 2.8443 | 0.0640775 | 0.000357613 | 0.00429586 | AF 44
1110585 | Nivel 2 | 2.8648 | 0.216278 | 0.000357613 | 0.0144996 | AF 44
1110591 | Nivel 2 | 2.32315 | 0.914646 | 0.000357613 | 0.0613193 | AF 44
1110593 | Nivel 2 | 3.2417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 44
1110599 | Nivel 2 | 3.2622 | 0.216278 | 0.000357613 | 0.0144996 | AF 44
1110603 | Nivel 2 | 2.32315 | 0.714649 | 0.000357613 | 0.0479112 | AF 44
1110605 | Nivel 2 | 3.0417 | 0.0640775 | 0.000357613 | 0.00429586 | AF 44
1110611 | Nivel 2 | 3.0622 | 0.216278 | 0.000357613 | 0.0144996 | AF 44
1110621 | Nivel 2 | 2.32315 | 0.614649 | 0.000357613 | 0.041207 | AF 44
1110623 | Nivel 2 | 2.9417 | 0.0540775 | 0.000357613 | 0.00362544 | AF 44
1110629 | Nivel 2 | 2.9622 | 0.216278 | 0.000357613 | 0.0144996 | AF 44
1110637 | Nivel 2 | 2.32315 | 1.01465 | 0.000357613 | 0.0680237 | AF 44
1110639 | Nivel 2 | 3.3417 | 0.0760338 | 0.000357613 | 0.00509742 | AF 44
1110643 | Nivel 2 | 3.3622 | 0.191278 | 0.000357613 | 0.0128235 | AF 44
1110647 | Nivel 2 | 3.36304 | 0.0554562 | 0.000357613 | 0.00371788 | AF 44
1110652 | Nivel 2 | 3.4815 | 0.0685 | 0.000357613 | 0.00459235 | AF 44
1110654 | Nivel 2 | 2.30181 | 0.236602 | 0.000357613 | 0.0158622 | AF 44
1110657 | Nivel 2 | 2.30181 | 0.0765385 | 0.000357613 | 0.00513126 | AF 44
1110662 | Nivel 2 | 2.299 | 5.2737 | 0.000558561 | 0.441864 | AF 1
1110664 | Nivel 2 | 2.29899 | 1.86525 | 0.000558561 | 0.156282 | AF 1
1110668 | Nivel 2 | 2.29964 | 0.394811 | 0.000558561 | 0.0330798 | AF 30
1110670 | Nivel 2 | 2.29901 | 1.86525 | 0.000558561 | 0.156282 | AF 16
1110676 | Nivel 2 | 2.2992 | 1.3787 | 0.000558561 | 0.115516 | AF 44
1110680 | Nivel 2 | 2.2992 | 4.01463 | 0.000558561 | 0.336371 | AF 44
1110684 | Nivel 2 | 2.2992 | 1.80486 | 0.000558561 | 0.151223 | AF 44
1110688 | Nivel 2 | 2.32575 | 0.378703 | 0.000558561 | 0.0317301 | AF 44
1110692 | Nivel 2 | 2.7092 | 0.0812029 | 0.000558561 | 0.00680369 | AF 44
1110696 | Nivel 2 | 2.32555 | 0.543703 | 0.000558561 | 0.0455548 | AF 1
1110700 | Nivel 2 | 2.87399 | 0.124301 | 0.000558561 | 0.0104147 | AF 1
1110704 | Nivel 2 | 2.32557 | 0.723703 | 0.000558561 | 0.0606363 | AF 16
1110708 | Nivel 2 | 3.05401 | 0.169301 | 0.000558561 | 0.0141851 | AF 16
1110712 | Nivel 2 | 2.32619 | 0.873703 | 0.000558561 | 0.0732043 | AF 30
1110716 | Nivel 2 | 3.20464 | 0.209301 | 0.000558561 | 0.0175366 | AF 30
1110745 | Nivel 2 | 2.30181 | 0.533258 | 0.000357613 | 0.0357505 | AF 44
1110933 | Nivel 2 | 2.30162 | 0.380945 | 0.000357613 | 0.0255392 | AF 1
1111143 | Nivel 2 | 2.30162 | 0.508257 | 0.000357613 | 0.0340743 | AF 16
1111403 | Nivel 2 | 2.30224 | 0.245114 | 0.000357613 | 0.0164329 | AF 30
1112750 | Nivel 1 | -0.0510049 | 1.74591 | 0.000558561 | 0.146283 | AF 3
1112754 | Nivel 1 | -0.0483812 | 0.818034 | 0.000357613 | 0.0548423 | AF 3
1112759 | Nivel 1 | -0.0509862 | 0.878204 | 0.000558561 | 0.0735814 | AF 3
1112762 | Nivel 1 | -0.0483812 | 0.591494 | 0.000357613 | 0.0396547 | AF 3
1112764 | Nivel 1 | -0.0483812 | 0.380489 | 0.000357613 | 0.0255086 | AF 3
1112768 | Nivel 1 | -0.0483812 | 0.413669 | 0.000357613 | 0.027733 | AF 3
1112771 | Nivel 1 | -0.0509862 | 1.76723 | 0.000558561 | 0.148069 | AF 3
1112774 | Nivel 1 | -0.0483812 | 0.313599 | 0.000357613 | 0.0210242 | AF 3
1112778 | Nivel 1 | -0.0483812 | 0.315695 | 0.000357613 | 0.0211647 | AF 3
1112781 | Nivel 1 | -0.0483812 | 0.154017 | 0.000357613 | 0.0103256 | AF 3
1112784 | Nivel 1 | -0.0483812 | 0.876288 | 0.000357613 | 0.0587478 | AF 3
1112786 | Nivel 1 | -0.0483812 | 0.9856 | 0.000357613 | 0.0660762 | AF 3
1112788 | Nivel 1 | -0.0483812 | 0.483762 | 0.000357613 | 0.0324322 | AF 3
1112792 | Nivel 1 | -0.0483812 | 0.753174 | 0.000357613 | 0.050494 | AF 3
1112796 | Nivel 1 | -0.0483812 | 0.206956 | 0.000357613 | 0.0138747 | AF 3
1112798 | Nivel 1 | -0.0483812 | 0.486997 | 0.000357613 | 0.0326491 | AF 3
1112804 | Nivel 1 | -0.0270375 | 1.11399 | 0.000357613 | 0.0746839 | AF 3
1112806 | Nivel 1 | 1.0917 | 0.0776598 | 0.000357613 | 0.00520644 | AF 3
1112812 | Nivel 1 | -0.0483812 | 0.736455 | 0.000357613 | 0.0493731 | AF 3
1112816 | Nivel 1 | -0.0270375 | 0.264838 | 0.000357613 | 0.0177551 | AF 3
1112818 | Nivel 1 | 0.2417 | 0.0690775 | 0.000357613 | 0.00463107 | AF 3
1112824 | Nivel 1 | 0.2622 | 0.216278 | 0.000357613 | 0.0144996 | AF 3
1112830 | Nivel 1 | -0.0270375 | 0.517438 | 0.000357613 | 0.0346898 | AF 3
1112832 | Nivel 1 | 0.4943 | 0.0640775 | 0.000357613 | 0.00429586 | AF 3
1112838 | Nivel 1 | 0.5148 | 0.216278 | 0.000357613 | 0.0144996 | AF 3
1112844 | Nivel 1 | -0.0270375 | 0.914838 | 0.000357613 | 0.0613322 | AF 3
1112846 | Nivel 1 | 0.8917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 3
1112852 | Nivel 1 | 0.9122 | 0.216278 | 0.000357613 | 0.0144996 | AF 3
1112856 | Nivel 1 | -0.0270375 | 0.714838 | 0.000357613 | 0.0479238 | AF 3
1112858 | Nivel 1 | 0.6917 | 0.080355 | 0.000357613 | 0.00538713 | AF 3
1112864 | Nivel 1 | 0.7122 | 0.216278 | 0.000357613 | 0.0144996 | AF 3
1112874 | Nivel 1 | -0.0270375 | 0.614838 | 0.000357613 | 0.0412197 | AF 3
1112876 | Nivel 1 | 0.5917 | 0.0540775 | 0.000357613 | 0.00362544 | AF 3
1112882 | Nivel 1 | 0.6122 | 0.216278 | 0.000357613 | 0.0144996 | AF 3
1112890 | Nivel 1 | -0.0270375 | 1.01484 | 0.000357613 | 0.0680363 | AF 3
1112892 | Nivel 1 | 0.9917 | 0.0760338 | 0.000357613 | 0.00509742 | AF 3
1112896 | Nivel 1 | 1.0122 | 0.191278 | 0.000357613 | 0.0128235 | AF 3
1112900 | Nivel 1 | 1.01304 | 0.0554563 | 0.000357613 | 0.00371788 | AF 3
1112905 | Nivel 1 | 1.1315 | 0.0685 | 0.000357613 | 0.00459235 | AF 3
1112907 | Nivel 1 | -0.0509862 | 0.653703 | 0.000558561 | 0.0547713 | AF 17
1112909 | Nivel 1 | -0.0509862 | 1.96106 | 0.000558561 | 0.16431 | AF 17
1112913 | Nivel 1 | -0.0483812 | 0.75842 | 0.000357613 | 0.0508457 | AF 17
1112918 | Nivel 1 | -0.0509862 | 0.937817 | 0.000558561 | 0.0785762 | AF 17
1112921 | Nivel 1 | -0.0483812 | 0.444182 | 0.000357613 | 0.0297786 | AF 17
1112923 | Nivel 1 | -0.0483812 | 0.499293 | 0.000357613 | 0.0334734 | AF 17
1112927 | Nivel 1 | -0.0483812 | 0.529611 | 0.000357613 | 0.0355059 | AF 17
1112930 | Nivel 1 | -0.0509862 | 1.68954 | 0.000558561 | 0.14156 | AF 17
1112933 | Nivel 1 | -0.0483812 | 0.313599 | 0.000357613 | 0.0210242 | AF 17
1112937 | Nivel 1 | -0.0483812 | 0.213913 | 0.000357613 | 0.014341 | AF 17
1112939 | Nivel 1 | -0.0483812 | 0.77535 | 0.000357613 | 0.0519807 | AF 17
1112941 | Nivel 1 | -0.0483812 | 0.664404 | 0.000357613 | 0.0445427 | AF 17
1112943 | Nivel 1 | -0.0483812 | 0.483762 | 0.000357613 | 0.0324322 | AF 17
1112947 | Nivel 1 | -0.0483812 | 0.791537 | 0.000357613 | 0.0530659 | AF 17
1112951 | Nivel 1 | -0.0483812 | 0.0618916 | 0.000357613 | 0.00414931 | AF 17
1112953 | Nivel 1 | -0.0483812 | 0.486997 | 0.000357613 | 0.0326491 | AF 17
1112959 | Nivel 1 | -0.0270375 | 1.11399 | 0.000357613 | 0.0746839 | AF 17
1112961 | Nivel 1 | 1.0917 | 0.0776598 | 0.000357613 | 0.00520644 | AF 17
1112967 | Nivel 1 | -0.0483812 | 0.736455 | 0.000357613 | 0.0493731 | AF 17
1112971 | Nivel 1 | -0.0270375 | 0.264838 | 0.000357613 | 0.0177551 | AF 17
1112973 | Nivel 1 | 0.2417 | 0.0690775 | 0.000357613 | 0.00463107 | AF 17
1112979 | Nivel 1 | 0.2622 | 0.216278 | 0.000357613 | 0.0144996 | AF 17
1112985 | Nivel 1 | -0.0270375 | 0.517438 | 0.000357613 | 0.0346898 | AF 17
1112987 | Nivel 1 | 0.4943 | 0.0640775 | 0.000357613 | 0.00429586 | AF 17
1112993 | Nivel 1 | 0.5148 | 0.216278 | 0.000357613 | 0.0144996 | AF 17
1112999 | Nivel 1 | -0.0270375 | 0.914838 | 0.000357613 | 0.0613322 | AF 17
1113001 | Nivel 1 | 0.8917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 17
1113007 | Nivel 1 | 0.9122 | 0.216278 | 0.000357613 | 0.0144996 | AF 17
1113011 | Nivel 1 | -0.0270375 | 0.714838 | 0.000357613 | 0.0479238 | AF 17
1113013 | Nivel 1 | 0.6917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 17
1113019 | Nivel 1 | 0.7122 | 0.216278 | 0.000357613 | 0.0144996 | AF 17
1113029 | Nivel 1 | -0.0270375 | 0.614838 | 0.000357613 | 0.0412197 | AF 17
1113031 | Nivel 1 | 0.5917 | 0.0540775 | 0.000357613 | 0.00362544 | AF 17
1113037 | Nivel 1 | 0.6122 | 0.216278 | 0.000357613 | 0.0144996 | AF 17
1113045 | Nivel 1 | -0.0270375 | 1.01484 | 0.000357613 | 0.0680363 | AF 17
1113047 | Nivel 1 | 0.9917 | 0.0760338 | 0.000357613 | 0.00509742 | AF 17
1113051 | Nivel 1 | 1.0122 | 0.191278 | 0.000357613 | 0.0128235 | AF 17
1113055 | Nivel 1 | 1.01304 | 0.0554562 | 0.000357613 | 0.00371788 | AF 17
1113060 | Nivel 1 | 1.1315 | 0.0685 | 0.000357613 | 0.00459235 | AF 17
1113064 | Nivel 1 | -0.0483805 | 0.241519 | 0.000357613 | 0.0161918 | AF 17
1113067 | Nivel 1 | -0.0483812 | 0.0765385 | 0.000357613 | 0.00513126 | AF 17
1113072 | Nivel 1 | -0.0503612 | 0.613703 | 0.000558561 | 0.0514198 | AF 31
1113074 | Nivel 1 | -0.0503612 | 1.73606 | 0.000558561 | 0.145458 | AF 31
1113078 | Nivel 1 | -0.0477562 | 0.818034 | 0.000357613 | 0.0548423 | AF 31
1113083 | Nivel 1 | -0.0503612 | 0.878204 | 0.000558561 | 0.0735814 | AF 31
1113086 | Nivel 1 | -0.0477562 | 0.727325 | 0.000357613 | 0.048761 | AF 31
1113088 | Nivel 1 | -0.0477562 | 0.494691 | 0.000357613 | 0.0331649 | AF 31
1113092 | Nivel 1 | -0.0477562 | 0.377444 | 0.000357613 | 0.0253044 | AF 31
1113095 | Nivel 1 | -0.0503612 | 1.6314 | 0.000558561 | 0.136689 | AF 31
1113098 | Nivel 1 | -0.0477562 | 0.313599 | 0.000357613 | 0.0210242 | AF 31
1113102 | Nivel 1 | -0.0477562 | 0.315695 | 0.000357613 | 0.0211647 | AF 31
1113105 | Nivel 1 | -0.0477562 | 0.0398154 | 0.000357613 | 0.00266928 | AF 31
1113108 | Nivel 1 | -0.0477562 | 0.876288 | 0.000357613 | 0.0587478 | AF 31
1113110 | Nivel 1 | -0.0477562 | 0.9856 | 0.000357613 | 0.0660762 | AF 31
1113112 | Nivel 1 | -0.0477562 | 0.483762 | 0.000357613 | 0.0324322 | AF 31
1113116 | Nivel 1 | -0.0477562 | 0.753174 | 0.000357613 | 0.050494 | AF 31
1113120 | Nivel 1 | -0.0477562 | 0.206956 | 0.000357613 | 0.0138747 | AF 31
1113122 | Nivel 1 | -0.0477562 | 0.486997 | 0.000357613 | 0.0326491 | AF 31
1113128 | Nivel 1 | -0.0264125 | 1.11337 | 0.000357613 | 0.074642 | AF 31
1113130 | Nivel 1 | 1.0917 | 0.0776598 | 0.000357613 | 0.00520644 | AF 31
1113136 | Nivel 1 | -0.0477562 | 0.736455 | 0.000357613 | 0.0493731 | AF 31
1113140 | Nivel 1 | -0.0264125 | 0.264213 | 0.000357613 | 0.0177132 | AF 31
1113142 | Nivel 1 | 0.2417 | 0.0690775 | 0.000357613 | 0.00463107 | AF 31
1113148 | Nivel 1 | 0.2622 | 0.216278 | 0.000357613 | 0.0144996 | AF 31
1113154 | Nivel 1 | -0.0264125 | 0.516813 | 0.000357613 | 0.0346479 | AF 31
1113156 | Nivel 1 | 0.4943 | 0.0640775 | 0.000357613 | 0.00429586 | AF 31
1113162 | Nivel 1 | 0.5148 | 0.216278 | 0.000357613 | 0.0144996 | AF 31
1113168 | Nivel 1 | -0.0264125 | 0.914213 | 0.000357613 | 0.0612903 | AF 31
1113170 | Nivel 1 | 0.8917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 31
1113176 | Nivel 1 | 0.9122 | 0.216278 | 0.000357613 | 0.0144996 | AF 31
1113180 | Nivel 1 | -0.0264125 | 0.714213 | 0.000357613 | 0.0478819 | AF 31
1113182 | Nivel 1 | 0.6917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 31
1113188 | Nivel 1 | 0.7122 | 0.216278 | 0.000357613 | 0.0144996 | AF 31
1113198 | Nivel 1 | -0.0264125 | 0.614213 | 0.000357613 | 0.0411778 | AF 31
1113200 | Nivel 1 | 0.5917 | 0.0540775 | 0.000357613 | 0.00362544 | AF 31
1113206 | Nivel 1 | 0.6122 | 0.216278 | 0.000357613 | 0.0144996 | AF 31
1113214 | Nivel 1 | -0.0264125 | 1.01421 | 0.000357613 | 0.0679944 | AF 31
1113216 | Nivel 1 | 0.9917 | 0.0760338 | 0.000357613 | 0.00509742 | AF 31
1113220 | Nivel 1 | 1.0122 | 0.191278 | 0.000357613 | 0.0128235 | AF 31
1113224 | Nivel 1 | 1.01304 | 0.0554563 | 0.000357613 | 0.00371788 | AF 31
1113229 | Nivel 1 | 1.1315 | 0.0685 | 0.000357613 | 0.00459235 | AF 31
1113233 | Nivel 1 | -0.0507977 | 1.2056 | 0.000558561 | 0.101013 | AF 45
1113235 | Nivel 1 | -0.0507977 | 1.96111 | 0.000558561 | 0.164314 | AF 45
1113239 | Nivel 1 | -0.0481927 | 0.78886 | 0.000357613 | 0.0528864 | AF 45
1113244 | Nivel 1 | -0.0507977 | 0.907378 | 0.000558561 | 0.0760258 | AF 45
1113247 | Nivel 1 | -0.0481927 | 0.436824 | 0.000357613 | 0.0292854 | AF 45
1113249 | Nivel 1 | -0.0481927 | 0.529732 | 0.000357613 | 0.0355141 | AF 45
1113253 | Nivel 1 | -0.048193 | 0.55827 | 0.000357613 | 0.0374273 | AF 45
1113256 | Nivel 1 | -0.0507977 | 1.6969 | 0.000558561 | 0.142177 | AF 45
1113259 | Nivel 1 | -0.0481927 | 0.313599 | 0.000357613 | 0.0210242 | AF 45
1113263 | Nivel 1 | -0.0481897 | 0.213913 | 0.000357613 | 0.014341 | AF 45
1113265 | Nivel 1 | -0.0481927 | 0.77535 | 0.000357613 | 0.0519807 | AF 45
1113267 | Nivel 1 | -0.0481927 | 0.731569 | 0.000357613 | 0.0490455 | AF 45
1113269 | Nivel 1 | -0.0481927 | 0.483762 | 0.000357613 | 0.0324322 | AF 45
1113273 | Nivel 1 | -0.0481927 | 0.754811 | 0.000357613 | 0.0506038 | AF 45
1113277 | Nivel 1 | -0.0481927 | 0.0943034 | 0.000357613 | 0.00632225 | AF 45
1113279 | Nivel 1 | -0.0481927 | 0.486997 | 0.000357613 | 0.0326491 | AF 45
1113285 | Nivel 1 | -0.026849 | 1.11381 | 0.000357613 | 0.0746713 | AF 45
1113287 | Nivel 1 | 1.0917 | 0.0776598 | 0.000357613 | 0.00520644 | AF 45
1113293 | Nivel 1 | -0.0481927 | 0.736455 | 0.000357613 | 0.0493731 | AF 45
1113297 | Nivel 1 | -0.026849 | 0.264649 | 0.000357613 | 0.0177425 | AF 45
1113299 | Nivel 1 | 0.2417 | 0.0690775 | 0.000357613 | 0.00463107 | AF 45
1113305 | Nivel 1 | 0.2622 | 0.216278 | 0.000357613 | 0.0144996 | AF 45
1113311 | Nivel 1 | -0.026849 | 0.517249 | 0.000357613 | 0.0346772 | AF 45
1113313 | Nivel 1 | 0.4943 | 0.0640775 | 0.000357613 | 0.00429586 | AF 45
1113319 | Nivel 1 | 0.5148 | 0.216278 | 0.000357613 | 0.0144996 | AF 45
1113325 | Nivel 1 | -0.0268459 | 0.914646 | 0.000357613 | 0.0613193 | AF 45
1113327 | Nivel 1 | 0.8917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 45
1113333 | Nivel 1 | 0.9122 | 0.216278 | 0.000357613 | 0.0144996 | AF 45
1113337 | Nivel 1 | -0.026849 | 0.714649 | 0.000357613 | 0.0479112 | AF 45
1113339 | Nivel 1 | 0.6917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 45
1113345 | Nivel 1 | 0.7122 | 0.216278 | 0.000357613 | 0.0144996 | AF 45
1113355 | Nivel 1 | -0.026849 | 0.614649 | 0.000357613 | 0.041207 | AF 45
1113357 | Nivel 1 | 0.5917 | 0.0540775 | 0.000357613 | 0.00362544 | AF 45
1113363 | Nivel 1 | 0.6122 | 0.216278 | 0.000357613 | 0.0144996 | AF 45
1113371 | Nivel 1 | -0.026849 | 1.01465 | 0.000357613 | 0.0680237 | AF 45
1113373 | Nivel 1 | 0.9917 | 0.0760338 | 0.000357613 | 0.00509742 | AF 45
1113377 | Nivel 1 | 1.0122 | 0.191278 | 0.000357613 | 0.0128235 | AF 45
1113381 | Nivel 1 | 1.01304 | 0.0554562 | 0.000357613 | 0.00371788 | AF 45
1113386 | Nivel 1 | 1.1315 | 0.0685 | 0.000357613 | 0.00459235 | AF 45
1113388 | Nivel 1 | -0.0481949 | 0.206602 | 0.000357613 | 0.013851 | AF 45
1113391 | Nivel 1 | -0.0481927 | 0.0765385 | 0.000357613 | 0.00513126 | AF 45
1113396 | Nivel 1 | -0.0510049 | 5.2737 | 0.000558561 | 0.441864 | AF 3
1113398 | Nivel 1 | -0.051005 | 1.86525 | 0.000558561 | 0.156282 | AF 3
1113402 | Nivel 1 | -0.0503612 | 0.394811 | 0.000558561 | 0.0330798 | AF 31
1113404 | Nivel 1 | -0.0509862 | 1.8751 | 0.000558561 | 0.157108 | AF 17
1113410 | Nivel 1 | -0.0508049 | 1.3887 | 0.000558561 | 0.116354 | AF 45
1113414 | Nivel 1 | -0.050805 | 3.9937 | 0.000558561 | 0.334617 | AF 45
1113418 | Nivel 1 | -0.050805 | 1.81486 | 0.000558561 | 0.152061 | AF 45
1113422 | Nivel 1 | -0.0242513 | 0.378703 | 0.000558561 | 0.0317301 | AF 45
1113426 | Nivel 1 | 0.359195 | 0.0812029 | 0.000558561 | 0.00680369 | AF 45
1113430 | Nivel 1 | -0.0244513 | 0.543703 | 0.000558561 | 0.0455548 | AF 3
1113434 | Nivel 1 | 0.523995 | 0.124301 | 0.000558561 | 0.0104147 | AF 3
1113438 | Nivel 1 | -0.0244325 | 0.723703 | 0.000558561 | 0.0606363 | AF 17
1113442 | Nivel 1 | 0.704014 | 0.169301 | 0.000558561 | 0.0141851 | AF 17
1113446 | Nivel 1 | -0.0238075 | 0.873703 | 0.000558561 | 0.0732043 | AF 31
1113450 | Nivel 1 | 0.854639 | 0.209301 | 0.000558561 | 0.0175366 | AF 31
1113454 | Nivel 1 | -0.0481927 | 0.535616 | 0.000357613 | 0.0359085 | AF 45
1113462 | Nivel 1 | -0.0483812 | 0.380945 | 0.000357613 | 0.0255392 | AF 3
1113470 | Nivel 1 | -0.0483813 | 0.528258 | 0.000357613 | 0.0354152 | AF 17
1113476 | Nivel 1 | -0.0477563 | 0.245114 | 0.000357613 | 0.0164329 | AF 31
1113925 | Nivel 3 | 4.649 | 1.74591 | 0.000558561 | 0.146283 | AF 4
1113929 | Nivel 3 | 4.65162 | 0.888034 | 0.000357613 | 0.0595352 | AF 4
1113934 | Nivel 3 | 4.64901 | 0.808204 | 0.000558561 | 0.0677164 | AF 4
1113937 | Nivel 3 | 4.65162 | 0.591494 | 0.000357613 | 0.0396547 | AF 4
1113939 | Nivel 3 | 4.65162 | 0.380489 | 0.000357613 | 0.0255086 | AF 4
1113943 | Nivel 3 | 4.65162 | 0.483669 | 0.000357613 | 0.0324259 | AF 4
1113946 | Nivel 3 | 4.64901 | 1.76723 | 0.000558561 | 0.148069 | AF 4
1113949 | Nivel 3 | 4.65162 | 0.313599 | 0.000357613 | 0.0210242 | AF 4
1113953 | Nivel 3 | 4.65162 | 0.315695 | 0.000357613 | 0.0211647 | AF 4
1113956 | Nivel 3 | 4.65162 | 0.224017 | 0.000357613 | 0.0150185 | AF 4
1113959 | Nivel 3 | 4.65162 | 0.876288 | 0.000357613 | 0.0587478 | AF 4
1113961 | Nivel 3 | 4.65162 | 1.0556 | 0.000357613 | 0.0707691 | AF 4
1113963 | Nivel 3 | 4.65162 | 0.483762 | 0.000357613 | 0.0324322 | AF 4
1113967 | Nivel 3 | 4.65162 | 0.753174 | 0.000357613 | 0.050494 | AF 4
1113971 | Nivel 3 | 4.65162 | 0.136956 | 0.000357613 | 0.00918176 | AF 4
1113973 | Nivel 3 | 4.65162 | 0.486997 | 0.000357613 | 0.0326491 | AF 4
1113979 | Nivel 3 | 4.67296 | 1.11399 | 0.000357613 | 0.0746839 | AF 4
1113981 | Nivel 3 | 5.7917 | 0.0776598 | 0.000357613 | 0.00520644 | AF 4
1113987 | Nivel 3 | 4.65162 | 0.736455 | 0.000357613 | 0.0493731 | AF 4
1113991 | Nivel 3 | 4.67296 | 0.264838 | 0.000357613 | 0.0177551 | AF 4
1113993 | Nivel 3 | 4.9417 | 0.0690775 | 0.000357613 | 0.00463107 | AF 4
1113999 | Nivel 3 | 4.9622 | 0.216278 | 0.000357613 | 0.0144996 | AF 4
1114005 | Nivel 3 | 4.67296 | 0.517438 | 0.000357613 | 0.0346898 | AF 4
1114007 | Nivel 3 | 5.1943 | 0.0640775 | 0.000357613 | 0.00429586 | AF 4
1114013 | Nivel 3 | 5.2148 | 0.216278 | 0.000357613 | 0.0144996 | AF 4
1114019 | Nivel 3 | 4.67296 | 0.914838 | 0.000357613 | 0.0613322 | AF 4
1114021 | Nivel 3 | 5.5917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 4
1114027 | Nivel 3 | 5.6122 | 0.216278 | 0.000357613 | 0.0144996 | AF 4
1114031 | Nivel 3 | 4.67296 | 0.714838 | 0.000357613 | 0.0479238 | AF 4
1114033 | Nivel 3 | 5.3917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 4
1114039 | Nivel 3 | 5.4122 | 0.216278 | 0.000357613 | 0.0144996 | AF 4
1114049 | Nivel 3 | 4.67296 | 0.614838 | 0.000357613 | 0.0412197 | AF 4
1114051 | Nivel 3 | 5.2917 | 0.0540775 | 0.000357613 | 0.00362544 | AF 4
1114057 | Nivel 3 | 5.3122 | 0.216278 | 0.000357613 | 0.0144996 | AF 4
1114065 | Nivel 3 | 4.67296 | 1.01484 | 0.000357613 | 0.0680363 | AF 4
1114067 | Nivel 3 | 5.6917 | 0.0760338 | 0.000357613 | 0.00509742 | AF 4
1114071 | Nivel 3 | 5.7122 | 0.191278 | 0.000357613 | 0.0128235 | AF 4
1114075 | Nivel 3 | 5.71304 | 0.0554563 | 0.000357613 | 0.00371788 | AF 4
1114080 | Nivel 3 | 5.8315 | 0.0685 | 0.000357613 | 0.00459235 | AF 4
1114082 | Nivel 3 | 4.64901 | 0.653703 | 0.000558561 | 0.0547713 | AF 19
1114084 | Nivel 3 | 4.64901 | 1.96106 | 0.000558561 | 0.16431 | AF 19
1114088 | Nivel 3 | 4.65162 | 0.75842 | 0.000357613 | 0.0508457 | AF 19
1114093 | Nivel 3 | 4.64901 | 0.937817 | 0.000558561 | 0.0785762 | AF 19
1114096 | Nivel 3 | 4.65162 | 0.564182 | 0.000357613 | 0.0378236 | AF 19
1114098 | Nivel 3 | 4.65162 | 0.499293 | 0.000357613 | 0.0334734 | AF 19
1114102 | Nivel 3 | 4.65162 | 0.529611 | 0.000357613 | 0.0355059 | AF 19
1114105 | Nivel 3 | 4.64901 | 1.56954 | 0.000558561 | 0.131506 | AF 19
1114108 | Nivel 3 | 4.65162 | 0.313599 | 0.000357613 | 0.0210242 | AF 19
1114112 | Nivel 3 | 4.65162 | 0.213913 | 0.000357613 | 0.014341 | AF 19
1114114 | Nivel 3 | 4.65162 | 0.77535 | 0.000357613 | 0.0519807 | AF 19
1114116 | Nivel 3 | 4.65162 | 0.664404 | 0.000357613 | 0.0445427 | AF 19
1114118 | Nivel 3 | 4.65162 | 0.483762 | 0.000357613 | 0.0324322 | AF 19
1114122 | Nivel 3 | 4.65162 | 0.791537 | 0.000357613 | 0.0530659 | AF 19
1114126 | Nivel 3 | 4.65162 | 0.0668916 | 0.000357613 | 0.00448452 | AF 19
1114128 | Nivel 3 | 4.65162 | 0.486997 | 0.000357613 | 0.0326491 | AF 19
1114134 | Nivel 3 | 4.67296 | 1.11399 | 0.000357613 | 0.0746839 | AF 19
1114136 | Nivel 3 | 5.7917 | 0.0776598 | 0.000357613 | 0.00520644 | AF 19
1114142 | Nivel 3 | 4.65162 | 0.736455 | 0.000357613 | 0.0493731 | AF 19
1114146 | Nivel 3 | 4.67296 | 0.264838 | 0.000357613 | 0.0177551 | AF 19
1114148 | Nivel 3 | 4.9417 | 0.0690775 | 0.000357613 | 0.00463107 | AF 19
1114154 | Nivel 3 | 4.9622 | 0.216278 | 0.000357613 | 0.0144996 | AF 19
1114160 | Nivel 3 | 4.67296 | 0.517438 | 0.000357613 | 0.0346898 | AF 19
1114162 | Nivel 3 | 5.1943 | 0.0640775 | 0.000357613 | 0.00429586 | AF 19
1114168 | Nivel 3 | 5.2148 | 0.216278 | 0.000357613 | 0.0144996 | AF 19
1114174 | Nivel 3 | 4.67296 | 0.914838 | 0.000357613 | 0.0613322 | AF 19
1114176 | Nivel 3 | 5.5917 | 0.0640775 | 0.000357613 | 0.00429586 | AF 19
1114182 | Nivel 3 | 5.6122 | 0.216278 | 0.000357613 | 0.0144996 | AF 19
