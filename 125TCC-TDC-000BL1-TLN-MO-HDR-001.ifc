Properties of the parts of a building model (IFC4), part 7 of 21

# IfcDistributionPort (13044)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_1106632_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 14
Port_1106630_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 14
Port_1106632_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 14
Port_1106630_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 14
Port_1106638_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 14
Port_1106634_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 14
Port_1106636_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 14
Port_1106634_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 14
Port_1106638_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 14
Port_1106842_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1106899_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1106887_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1106899_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1106887_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1106932_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1106899_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1106900_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1106932_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1106934_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1106934_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1106936_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1107003_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1107053_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1107045_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1107053_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1107045_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1107072_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1107053_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1107054_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1107072_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1107074_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1107074_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1107076_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1110016_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110018_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110016_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110022_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110018_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110662_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110020_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110152_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110020_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110154_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110022_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110025_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110024_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110025_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110024_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110154_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110024_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110037_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110028_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110042_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110028_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110032_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110030_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110046_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110030_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110136_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110032_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110050_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110032_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110047_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110034_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1111061_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110034_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1111063_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110036_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110037_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110036_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110042_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110036_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1111063_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110040_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110136_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110040_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110138_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110044_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110134_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110044_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110046_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110046_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110047_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110050_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110060_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110052_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110060_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110052_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110056_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110054_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110056_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110054_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110094_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110056_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110058_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110058_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110068_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110060_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110062_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110062_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110066_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110064_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110066_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110064_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110108_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110068_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110078_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110070_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110080_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110070_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110074_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110072_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110074_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110072_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110076_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110078_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110080_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110082_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110094_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110082_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110088_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110084_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110088_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110084_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110086_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110088_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110090_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110090_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110092_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110096_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110108_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110096_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110102_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110098_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110102_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110098_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110100_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110102_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110104_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110104_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110106_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110110_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110116_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110110_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110134_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110112_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110116_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110112_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110114_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110116_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110118_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110118_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110120_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110122_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110128_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110122_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110138_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110124_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110128_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110124_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110126_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110128_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110130_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110130_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110132_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110140_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110146_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110140_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110152_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110142_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110146_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110142_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110144_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110146_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110148_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110148_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110150_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110156_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110160_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110156_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110999_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110158_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110160_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110158_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110168_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110160_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110162_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110162_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110164_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110166_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110168_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110166_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110170_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110170_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110171_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110171_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110173_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110177_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110173_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110672_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110175_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110177_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110175_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110181_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110179_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110307_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110179_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110309_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110181_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110184_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110183_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110184_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110183_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110309_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110183_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110196_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110187_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110201_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110187_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110191_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110189_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110191_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110189_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110291_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110191_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110333_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110193_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1111214_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110193_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110328_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110195_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110196_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110195_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110201_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110195_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110328_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110199_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110291_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110199_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110293_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110203_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110289_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110203_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110336_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110205_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110332_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110205_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110215_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110207_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110215_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110207_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110211_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110209_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110211_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110209_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110249_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110211_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110213_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110213_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110223_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110215_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110217_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110217_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110221_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110219_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110221_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110219_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110263_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110223_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110233_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110225_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110235_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110225_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110229_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110227_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110229_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110227_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110231_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110233_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110235_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110237_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110249_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110237_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110243_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110239_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110243_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110239_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110241_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110243_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110245_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110245_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110247_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110251_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110263_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110251_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110257_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110253_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110257_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110253_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110255_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110257_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110259_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110259_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110261_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110265_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110271_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110265_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110289_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110267_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110271_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110267_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110269_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110271_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110273_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110273_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110275_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110277_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110283_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110277_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110293_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110279_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110283_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110279_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110281_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110283_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110285_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110285_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110287_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110295_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110301_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110295_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110307_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110297_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110301_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110297_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110299_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110301_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110303_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110303_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110305_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110311_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110315_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110311_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1111216_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110313_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110315_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110313_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110323_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110315_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110317_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110317_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110319_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110321_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110323_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110321_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110325_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110325_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110326_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110326_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110330_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110332_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110330_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110336_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110332_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110333_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110338_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110342_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110338_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110674_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110340_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110342_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110340_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110346_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110344_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110476_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110344_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110478_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110346_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110349_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110348_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110349_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110348_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110478_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110348_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110361_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110352_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110366_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110352_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110356_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110354_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110370_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110354_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110460_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110356_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110374_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110356_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110371_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110358_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1111478_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110358_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110497_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110360_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110361_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110360_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110366_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110360_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110497_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110364_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110460_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110364_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110462_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110368_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110458_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110368_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110370_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110370_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110371_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110374_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110384_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110376_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110384_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110376_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110380_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110378_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110380_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110378_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110418_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110380_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110382_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110382_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110392_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110384_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110386_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110386_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110390_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110388_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110390_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110388_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110432_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110392_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110402_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110394_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110404_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110394_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110398_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110396_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110398_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110396_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110400_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110402_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110404_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110406_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110418_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110406_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110412_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110408_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110412_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110408_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110410_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110412_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110414_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110414_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110416_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110420_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110432_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110420_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110426_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110422_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110426_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110422_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110424_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110426_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110428_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110428_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110430_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110434_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110440_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110434_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110458_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110436_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110440_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110436_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110438_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110440_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110442_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110442_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110444_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110446_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110452_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110446_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110462_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110448_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110452_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110448_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110450_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110452_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110454_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110454_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110456_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110464_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110470_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110464_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110476_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110466_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110470_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110466_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110468_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110470_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110472_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110472_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110474_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110480_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110484_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110480_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1111480_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110482_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110484_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110482_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110492_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110484_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110486_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110486_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110488_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110490_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110492_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110490_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110494_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110494_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110495_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110495_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110499_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110503_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110499_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110678_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110501_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110503_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110501_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110507_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110505_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110633_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110505_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110635_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110507_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110510_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110509_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110510_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110509_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110635_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110509_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110522_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110513_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110527_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110513_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110517_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110515_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110517_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110515_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110617_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110517_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110657_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110519_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110797_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110519_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110825_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110521_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110522_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110521_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110527_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110521_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110825_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110525_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110617_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110525_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110619_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110529_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110615_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110529_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110660_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110531_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110656_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110531_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110541_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110533_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110541_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110533_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110537_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110535_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110537_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110535_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110575_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110537_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110539_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110539_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110549_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110541_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110543_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110543_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110547_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110545_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110547_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110545_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110589_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110549_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110559_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110551_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110561_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110551_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110555_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110553_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110555_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110553_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110557_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110559_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110561_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110563_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110575_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110563_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110569_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110565_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110569_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110565_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110567_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110569_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110571_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110571_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110573_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110577_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110589_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110577_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110583_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110579_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110583_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110579_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110581_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110583_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110585_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110585_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110587_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110591_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110597_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110591_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110615_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110593_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110597_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110593_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110595_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110597_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110599_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110599_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110601_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110603_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110609_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110603_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110619_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110605_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110609_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110605_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110607_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110609_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110611_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110611_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110613_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110621_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110627_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110621_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110633_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110623_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110627_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110623_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110625_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110627_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110629_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110629_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110631_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110637_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110641_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110637_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110782_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110639_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110641_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110639_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110649_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110641_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110643_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110643_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110645_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110647_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110649_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110647_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110651_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110651_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110652_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110652_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110654_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110656_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110654_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110660_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110656_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110657_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110662_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110666_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110664_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110666_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110664_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110698_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110668_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110674_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110668_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110714_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110670_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110672_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110670_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110706_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110676_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110678_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110676_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110682_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110680_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110682_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110680_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110686_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110684_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110686_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110684_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110690_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110688_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110690_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110688_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110694_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110692_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110694_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110692_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110696_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110698_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110696_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110702_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110700_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110702_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110700_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110704_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110706_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110704_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110710_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110708_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110710_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110708_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1110712_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110714_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110712_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110718_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110716_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110718_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110716_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1110745_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110782_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110745_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110797_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 44
Port_1110933_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110999_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1110933_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1111061_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 1
Port_1111143_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1111214_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1111143_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1111216_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 16
Port_1111403_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1111478_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1111403_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1111480_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 30
Port_1112750_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112752_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112750_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112756_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112752_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113396_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112754_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112886_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112754_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112888_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112756_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112759_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112758_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112759_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112758_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112888_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112758_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112771_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112762_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112776_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112762_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112766_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112764_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112780_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112764_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112870_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112766_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112784_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112766_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112781_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112768_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113466_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112768_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113468_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112770_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112771_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112770_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112776_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112770_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113468_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112774_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112870_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112774_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112872_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112778_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112868_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112778_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112780_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112780_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112781_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112784_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112794_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112786_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112794_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112786_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112790_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112788_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112790_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112788_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112828_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112790_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112792_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112792_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112802_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112794_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112796_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112796_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112800_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112798_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112800_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112798_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112842_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112802_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112812_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112804_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112814_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112804_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112808_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112806_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112808_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112806_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112810_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112812_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112814_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112816_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112828_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112816_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112822_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112818_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112822_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112818_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112820_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112822_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112824_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112824_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112826_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112830_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112842_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112830_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112836_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112832_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112836_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112832_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112834_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112836_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112838_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112838_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112840_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112844_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112850_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112844_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112868_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112846_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112850_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112846_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112848_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112850_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112852_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112852_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112854_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112856_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112862_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112856_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112872_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112858_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112862_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112858_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1243830_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112862_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112864_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112864_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112866_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112874_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112880_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112874_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112886_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112876_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112880_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112876_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112878_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112880_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112882_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
