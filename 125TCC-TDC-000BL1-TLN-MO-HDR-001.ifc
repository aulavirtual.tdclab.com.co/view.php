Properties of the parts of a building model (IFC4), part 1 of 21

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 96d467ee-7aee-45bd-a6c8-118f98a8e3a5, NumberOfSaves: 5], CoordinateReference [CoordinateBase: Shared Coordinates], ExchangeRequirement [BuildingService]
Time: 2024-11-18T11:39:54-05:00
Written by: ODA SDAI 22.12
Made in: 23.1.40.56 - Exporter 23.2.5.0 - Alternate UI 23.2.5.0

# IfcProject
Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 m
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 7
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:eBIM - Nivel (7)
Pset_BuildingStoreyCommon - Reference: eBIM - Nivel
Name | LongName | Elevation (m)
Nivel 1 | Nivel 1 | 0
Nivel 2 | Nivel 2 | 2.35
Nivel 3 | Nivel 3 | 4.7
Nivel 4 | Nivel 4 | 7.05
Nivel 5 | Nivel 5 | 9.4
Nivel 6 | Nivel 6 | 11.75
Nivel 7 | Nivel 7 | 14.1

# IfcBuildingElementProxy: Calentador Gas1:calentador 8 lts 2 (24)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: 21.04.20.10.20 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: calentador 8 lts 2
Pset_EnvironmentalImpactIndicators - Reference: calentador 8 lts 2
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.32952 m2; NetVolume: 0.0152256 m3
Name (Calentador Gas1:calentador 8 lts 2:...) | In
964631 | Nivel 1
1310310 | Nivel 1
1310324 | Nivel 1
1310358 | Nivel 1
1310387 | Nivel 1
1310394 | Nivel 1
1310401 | Nivel 1
1310408 | Nivel 1
1310425 | Nivel 2
1310432 | Nivel 2
1310439 | Nivel 2
1310446 | Nivel 2
1310463 | Nivel 3
1310470 | Nivel 3
1310477 | Nivel 3
1310484 | Nivel 3
1310501 | Nivel 4
1310508 | Nivel 4
1310515 | Nivel 4
1310522 | Nivel 4
1310539 | Nivel 5
1310546 | Nivel 5
1310553 | Nivel 5
1310560 | Nivel 5

# IfcBuildingElementProxy: D2060 - CAJILLA REG 2DA ETAPA Y 4 MED 1.6:D2060 - CAJILLA REG 2DA ETAPA Y 4 MED 1.6 (6)
Type - Material: Metal, CONCRETO
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: 21.04.20.60.30 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: D2060 - CAJILLA REG 2DA ETAPA Y 4 MED 1.6
Pset_EnvironmentalImpactIndicators - Reference: D2060 - CAJILLA REG 2DA ETAPA Y 4 MED 1.6
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.38425 m2; NetVolume: 0.0784435 m3
Name (D2060 - CAJILLA REG 2DA ETAPA Y 4 MED 1.6:D2060 - CAJILLA REG 2DA ETAPA Y 4 MED 1.6:...) | In
1054598 | Nivel 1
1191990 | Nivel 2
1192348 | Nivel 3
1192706 | Nivel 4
1193064 | Nivel 5
1193422 | Nivel 6

# IfcBuildingElementProxy: GABINETE CLASE 1 PEQUEÑO:GABINETE CLASE I (6)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: 21.04.40.10.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: GABINETE CLASE I
Pset_EnvironmentalImpactIndicators - Reference: GABINETE CLASE I
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.73115 m2; NetVolume: 0.00455687 m3
Name (GABINETE CLASE 1 PEQUEÑO:GABINETE CLASE I:...) | In
1208431 | Nivel 1
1208432 | Nivel 2
1208433 | Nivel 3
1208434 | Nivel 4
1208435 | Nivel 5
1208436 | Nivel 6

# IfcBuildingElementProxy: regulador caudal entre 12 a 55 m3:regulador caudal entre 12 a 55 m3, regulador caudal entre 12 a 55 m3:regulador caudal entre 12 a 55 m3:970311
In: Nivel 1
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: 21.04.30.10.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: regulador caudal entre 12 a 55 m3
Pset_EnvironmentalImpactIndicators - Reference: regulador caudal entre 12 a 55 m3
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.975 m2; NetVolume: 0.0545567 m3

# IfcDistributionPort (13044)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType | Group
Port_948051_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_956430_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948051_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948071_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948059_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948071_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948059_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948082_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948076_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948082_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948076_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948217_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948203_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948217_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948203_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948227_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948221_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948227_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948221_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_950588_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948442_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_954344_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948442_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948454_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948448_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948454_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948448_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948464_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948464_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948785_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948489_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948498_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948489_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948508_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948498_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948736_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948508_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948535_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948512_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948534_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948512_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_949521_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948526_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948534_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948526_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_952230_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948534_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948535_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948736_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948784_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948772_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948784_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948772_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_956218_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948784_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948785_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948788_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_956079_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948788_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_956218_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948823_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_949076_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_948823_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_954318_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_949076_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_949087_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_949081_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_949087_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_949081_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_949497_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_949468_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953329_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_949468_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_1092039_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_949497_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953534_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_949497_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_955409_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_949521_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_951923_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_950577_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_950588_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_950577_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_950860_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_950667_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_1091288_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_950667_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_951983_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_950667_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_950716_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_950716_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_950770_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_950770_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_950860_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_951923_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_955929_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_951983_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_955408_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_952230_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_954031_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953014_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953092_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953014_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953329_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953092_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953341_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953329_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953330_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953330_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953533_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953341_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953382_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953382_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_957400_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953382_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_957438_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953481_0 | SOURCEANDSINK | PIPE | VENT | VENT 1
Port_953789_1 | SOURCEANDSINK | PIPE | VENT | VENT 1
Port_953481_1 | SOURCEANDSINK | PIPE | VENT | VENT 1
Port_1092073_2 | SOURCEANDSINK | PIPE | VENT | VENT 1
Port_953533_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953534_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953533_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953738_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
InPort_953738_0 | SINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
OutPort_953533_3 | SOURCE | PIPE | DOMESTICCOLDWATER | AR-DOM 1
InPort_953789_3 | SINK | PIPE | VENT | VENT 1
OutPort_953738_1 | SOURCE | PIPE | DOMESTICCOLDWATER | VENT 1
Port_953789_2 | SOURCEANDSINK | PIPE | VENT | VENT 1
Port_1091397_1 | SOURCEANDSINK | PIPE | VENT | VENT 1
Port_953902_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_954031_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_953902_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_954277_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_954277_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_954305_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_954344_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_954346_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_954346_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_954362_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_954354_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_954362_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_954354_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_954380_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_955400_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_955408_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_955400_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_955933_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_955408_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_955409_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_955600_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_955929_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_955600_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_955933_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_956079_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_956228_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_956228_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_957140_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_956422_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_956430_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_956422_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_956438_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_956432_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_956438_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_956432_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_956455_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_957132_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_957140_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_957132_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_957172_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_957164_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_957172_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_957164_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_957209_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_957400_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_957467_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_957438_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_957461_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_958841_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_958859_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_958841_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965246_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_958851_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_958859_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_958851_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_959313_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_958861_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_959309_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_958861_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_959313_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_959232_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_959309_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_959232_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_959250_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_959240_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_959250_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_959240_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_959266_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963040_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963232_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963040_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963302_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963048_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963302_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963048_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963071_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963071_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963165_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963073_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963127_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963073_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963127_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963165_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963232_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965121_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963302_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963329_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963329_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_963359_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965121_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965312_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965238_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965246_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965238_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965254_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965248_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965254_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965248_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965314_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965258_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965312_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965258_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_965314_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 1
Port_1054979_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1330732_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1054979_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1330734_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1054993_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1330732_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1054993_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1059527_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1055047_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1055047_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1055069_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1055057_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1055069_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1055057_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1056349_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1055214_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1055214_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057097_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1056338_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1203633_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1056338_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1062403_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1056349_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1198576_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1057089_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057097_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057089_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057314_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057223_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057430_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057223_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057308_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057266_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057314_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057266_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057308_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057414_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057456_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057414_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057492_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057426_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057430_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057426_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059331_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057426_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057456_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057427_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059123_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057427_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1202561_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057472_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057494_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057472_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1062548_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057490_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057494_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057490_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1057492_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058417_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1062548_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
OutPort_1058417_2 | SOURCE | PIPE | FIREPROTECTION | RCI 1
Port_1058910_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059311_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058910_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059325_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058912_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059309_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058912_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1062550_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058920_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1062550_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
OutPort_1058920_2 | SOURCE | PIPE | FIREPROTECTION | RCI 1
Port_1058937_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059261_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058937_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059275_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058939_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059259_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058939_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1062552_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058947_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1062552_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
OutPort_1058947_2 | SOURCE | PIPE | FIREPROTECTION | RCI 1
Port_1058964_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059211_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058964_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059225_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058966_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059209_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058966_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1062554_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058974_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1062554_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
OutPort_1058974_2 | SOURCE | PIPE | FIREPROTECTION | RCI 1
Port_1058991_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059161_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058991_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059175_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058993_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059159_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1058993_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1062556_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059001_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1062556_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
OutPort_1059001_2 | SOURCE | PIPE | FIREPROTECTION | RCI 1
Port_1059018_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059111_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059018_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059125_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059020_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059109_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059020_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1062558_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059028_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1062558_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
OutPort_1059028_2 | SOURCE | PIPE | FIREPROTECTION | RCI 1
Port_1059107_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059109_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059107_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059111_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059113_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059133_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059113_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059123_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059113_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059125_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059114_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059173_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059114_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059133_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059157_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059159_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059157_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059161_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059163_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059183_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059163_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059173_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059163_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059175_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059164_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059223_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059164_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059183_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059207_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059209_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059207_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059211_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059213_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059233_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059213_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059223_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059213_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059225_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059214_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059273_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059214_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059233_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059257_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059259_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059257_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059261_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059263_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059283_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059263_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059273_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059263_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059275_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059264_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059323_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059264_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059283_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059307_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059309_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059307_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059311_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059313_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059333_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059313_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059323_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059313_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059325_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059314_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059331_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059314_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059333_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | RCI 1
Port_1059527_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060590_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060498_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060617_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060498_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060604_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060540_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060925_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060540_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060952_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060589_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060590_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060589_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060782_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060589_3 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060617_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060596_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060604_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060596_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060681_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060777_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060681_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060789_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060683_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060777_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060683_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060696_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060813_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060696_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1306593_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060698_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060813_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060698_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060711_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060849_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060711_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060960_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060713_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060849_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060713_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060726_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060885_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060726_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060954_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060728_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060885_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060728_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060741_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060925_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060741_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060745_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060743_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060745_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060743_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060781_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060782_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060781_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1306591_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060781_3 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060789_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060817_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060818_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060817_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060854_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060817_3 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1306593_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060818_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1306591_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060853_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060854_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060853_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060890_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060853_3 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060960_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060889_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060890_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060889_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060952_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060889_3 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1060954_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1061057_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1107881_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061057_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061065_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061358_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061065_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061066_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061065_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1107881_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061066_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1198581_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061138_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061394_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061138_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061149_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061362_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061149_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061160_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061320_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061160_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061171_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061269_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061171_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061182_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061238_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061182_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061211_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061236_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061211_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061212_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061211_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061238_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061212_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061261_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061236_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1203643_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061261_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061262_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061261_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061269_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061262_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061318_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061284_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061318_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061284_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061285_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061284_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061320_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061285_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061360_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061342_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061360_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061342_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061343_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061342_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061362_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061343_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061386_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061358_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061387_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061386_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061387_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061386_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1061394_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1062377_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1062403_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1062377_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 2
Port_1062683_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1330747_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1062683_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1330752_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1062693_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1330747_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1062693_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1062818_0 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1330752_2 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1062818_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1330754_1 | SOURCEANDSINK | PIPE | USERDEFINED | GAS 2
Port_1063660_0 | SOURCEANDSINK | PIPE | VENT | VENT 2
Port_1063660_1 | SOURCEANDSINK | PIPE | VENT | VENT 2
Port_1095352_2 | SOURCEANDSINK | PIPE | VENT | VENT 2
Port_1063784_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063788_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063784_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063935_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063786_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066288_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063786_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063814_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063788_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066084_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063790_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063812_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063790_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063814_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063804_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063812_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063804_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063808_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063806_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063808_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063806_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063810_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063911_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066757_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063911_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063924_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063913_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063924_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063913_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063915_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063915_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063920_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063917_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063919_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063917_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063919_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063920_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063924_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063926_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063926_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063928_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063933_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063935_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063933_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066753_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063937_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066753_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1063937_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066757_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1064554_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_1099557_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_1064554_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_1097060_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_1064728_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_1099806_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_1064728_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_1097930_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 1
Port_1065521_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065525_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065521_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065564_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065523_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065525_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065523_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065539_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065527_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065537_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065527_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065539_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065529_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065537_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065529_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065533_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065531_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065533_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065531_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065535_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065541_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065552_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065541_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065554_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065543_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065554_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065543_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065545_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065545_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065550_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065547_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065549_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065547_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065549_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065550_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065552_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065560_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065554_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065556_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065556_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065558_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065560_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065572_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065562_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065564_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065562_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065568_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065566_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065568_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065566_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065574_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065570_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065572_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065570_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1065574_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 4
Port_1066084_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066310_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066280_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066288_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066280_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066296_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066290_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066296_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066290_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066312_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066300_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066310_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066300_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066312_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 2
Port_1066476_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066480_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066476_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066519_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066478_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066535_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066478_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066494_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066480_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066531_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066482_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066492_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066482_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066494_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066484_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066492_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066484_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066488_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066486_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066488_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066486_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066490_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066496_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066792_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066496_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066509_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066498_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066509_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066498_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066500_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066500_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066505_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066502_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066504_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066502_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066504_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066505_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066509_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066511_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066511_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066513_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066515_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066792_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066515_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066796_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066517_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066519_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066517_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066796_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066531_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066543_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066533_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066535_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066533_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066539_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066537_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066539_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066537_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066545_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066541_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066543_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066541_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1066545_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 5
Port_1067274_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1067379_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1067274_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068575_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1067369_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1067379_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1067369_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1067394_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068181_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068189_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068181_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068214_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068189_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1072432_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068189_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1082197_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068203_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068214_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068203_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068230_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068401_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068419_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068401_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068547_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068419_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069332_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068419_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1072374_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068424_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068547_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068424_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070303_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068575_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069535_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068575_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068639_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1071573_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068639_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068664_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068652_1 | SOURCEANDSINK | PIPE |  | AR-DOM 4
Port_1068652_2 | SOURCEANDSINK | PIPE |  | AR-DOM 4
Port_1068655_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068664_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068655_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068675_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068669_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068675_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068669_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069766_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068873_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069349_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1068873_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069534_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069332_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069704_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069349_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069599_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069534_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1106900_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069534_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069535_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069599_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069625_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069696_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069704_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069696_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069715_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069715_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070736_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069753_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069766_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069753_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069774_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069768_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069774_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069768_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069784_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1069784_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070141_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070141_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070155_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070149_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070155_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070149_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070172_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070292_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070303_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070292_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070317_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070305_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070317_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070305_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070329_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070321_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070329_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070321_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070639_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
Port_1070633_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AR-DOM 4
