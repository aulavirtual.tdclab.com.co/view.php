Properties of the parts of a building model (IFC4), part 8 of 21

# IfcDistributionPort (13044)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_1112882_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112884_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112890_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112894_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112890_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113464_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112892_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112894_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112892_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112902_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112894_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112896_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112896_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112898_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112900_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112902_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112900_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112904_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112904_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112905_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112905_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1112907_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112911_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112907_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113406_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112909_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112911_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112909_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112915_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112913_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113041_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112913_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113043_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112915_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112918_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112917_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112918_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112917_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113043_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112917_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112930_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112921_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112935_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112921_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112925_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112923_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112925_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112923_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113025_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112925_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113067_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112927_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113472_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112927_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113062_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112929_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112930_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112929_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112935_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112929_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113062_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112933_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113025_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112933_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113027_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112937_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113023_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112937_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113070_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112939_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113066_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112939_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112949_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112941_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112949_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112941_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112945_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112943_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112945_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112943_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112983_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112945_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112947_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112947_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112957_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112949_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112951_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112951_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112955_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112953_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112955_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112953_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112997_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112957_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112967_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112959_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112969_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112959_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112963_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112961_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112963_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112961_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112965_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112967_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112969_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112971_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112983_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112971_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112977_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112973_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112977_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112973_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112975_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112977_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112979_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112979_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112981_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112985_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112997_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112985_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112991_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112987_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112991_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112987_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112989_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112991_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112993_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112993_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112995_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112999_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113005_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1112999_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113023_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113001_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113005_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113001_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113003_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113005_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113007_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113007_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113009_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113011_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113017_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113011_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113027_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113013_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113017_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113013_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113015_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113017_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113019_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113019_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113021_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113029_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113035_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113029_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113041_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113031_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113035_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113031_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113033_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113035_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113037_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113037_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113039_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113045_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113049_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113045_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113474_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113047_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113049_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113047_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113057_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113049_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113051_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113051_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113053_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113055_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113057_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113055_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113059_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113059_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113060_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113060_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113064_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113066_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113064_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113070_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113066_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113067_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113072_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113076_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113072_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113408_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113074_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113076_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113074_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113080_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113078_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113210_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113078_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113212_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113080_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113083_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113082_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113083_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113082_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113212_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113082_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113095_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113086_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113100_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113086_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113090_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113088_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113104_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113088_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113194_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113090_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113108_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113090_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113105_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113092_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113478_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113092_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113231_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113094_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113095_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113094_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113100_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113094_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113231_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113098_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113194_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113098_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113196_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113102_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113192_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113102_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113104_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113104_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113105_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113108_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113118_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113110_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113118_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113110_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113114_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113112_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113114_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113112_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113152_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113114_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113116_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113116_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113126_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113118_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113120_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113120_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113124_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113122_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113124_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113122_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113166_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113126_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113136_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113128_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113138_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113128_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113132_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113130_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113132_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113130_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113134_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113136_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113138_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113140_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113152_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113140_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113146_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113142_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113146_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113142_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113144_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113146_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113148_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113148_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113150_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113154_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113166_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113154_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113160_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113156_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113160_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113156_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113158_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113160_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113162_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113162_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113164_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113168_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113174_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113168_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113192_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113170_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113174_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113170_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113172_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113174_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113176_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113176_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113178_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113180_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113186_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113180_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113196_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113182_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113186_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113182_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113184_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113186_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113188_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113188_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113190_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113198_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113204_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113198_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113210_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113200_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113204_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113200_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113202_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113204_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113206_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113206_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113208_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113214_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113218_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113214_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113480_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113216_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113218_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113216_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113226_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113218_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113220_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113220_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113222_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113224_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113226_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113224_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113228_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113228_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113229_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113229_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113233_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113237_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113233_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113412_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113235_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113237_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113235_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113241_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113239_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113367_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113239_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113369_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113241_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113244_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113243_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113244_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113243_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113369_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113243_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113256_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113247_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113261_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113247_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113251_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113249_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113251_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113249_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113351_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113251_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113391_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113253_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113458_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113253_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113460_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113255_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113256_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113255_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113261_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113255_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113460_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113259_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113351_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113259_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113353_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113263_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113349_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113263_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113394_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113265_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113390_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113265_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113275_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113267_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113275_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113267_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113271_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113269_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113271_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113269_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113309_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113271_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113273_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113273_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113283_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113275_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113277_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113277_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113281_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113279_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113281_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113279_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113323_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113283_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113293_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113285_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113295_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113285_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113289_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113287_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113289_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113287_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113291_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113293_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113295_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113297_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113309_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113297_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113303_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113299_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113303_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113299_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113301_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113303_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113305_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113305_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113307_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113311_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113323_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113311_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113317_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113313_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113317_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113313_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113315_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113317_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113319_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113319_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113321_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113325_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113331_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113325_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113349_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113327_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113331_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113327_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113329_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113331_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113333_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113333_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113335_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113337_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113343_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113337_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113353_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113339_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113343_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113339_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113341_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113343_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113345_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113345_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113347_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113355_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113361_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113355_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113367_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113357_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113361_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113357_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113359_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113361_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113363_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113363_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113365_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113371_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113375_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113371_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113456_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113373_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113375_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113373_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113383_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113375_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113377_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113377_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113379_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113381_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113383_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113381_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113385_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113385_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113386_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113386_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113388_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113390_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113388_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113394_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113390_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113391_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113396_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113400_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113398_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113400_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113398_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113432_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113402_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113408_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113402_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113448_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113404_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113406_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113404_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113440_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113410_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113412_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113410_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113416_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113414_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113416_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113414_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113420_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113418_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113420_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113418_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113424_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113422_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113424_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113422_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113428_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113426_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113428_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113426_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113430_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113432_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113430_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113436_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113434_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113436_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113434_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113438_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113440_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113438_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113444_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113442_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113444_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113442_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113446_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113448_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113446_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113452_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113450_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113452_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113450_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113454_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113456_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113454_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113458_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 45
Port_1113462_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113464_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113462_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113466_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 3
Port_1113470_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113472_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113470_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113474_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 17
Port_1113476_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113478_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113476_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113480_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 31
Port_1113689_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113693_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113689_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113732_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113691_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113693_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113691_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113707_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113695_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113705_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113695_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113707_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113697_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113705_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113697_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113701_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113699_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113701_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113699_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113703_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113709_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113720_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113709_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113722_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113711_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113722_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113711_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113713_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113713_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113718_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113715_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113717_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113715_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113717_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113718_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113720_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113728_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113722_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113724_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113724_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113726_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113728_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113740_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113730_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113732_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113730_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113736_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113734_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113736_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113734_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113742_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113738_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113740_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113738_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113742_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 6
Port_1113744_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113748_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113744_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113783_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113746_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113846_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113746_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113762_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113748_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113842_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113750_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113760_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113750_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113762_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113752_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113760_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113752_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113756_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113754_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113756_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113754_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113758_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113764_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113919_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113764_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113775_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113766_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113775_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113766_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113768_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113768_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113773_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113770_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113772_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113770_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113772_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113773_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113775_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113777_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113777_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113779_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113781_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113783_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113781_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113917_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113785_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113917_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113785_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113919_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113787_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113791_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113787_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113830_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113789_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113791_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113789_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113805_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113793_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113803_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113793_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113805_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113795_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113803_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113795_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113799_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113797_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113799_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113797_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113801_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113807_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113818_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113807_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113820_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113809_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113820_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113809_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113811_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113811_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113816_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113813_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113815_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113813_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113815_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113816_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113818_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113826_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113820_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113822_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113822_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113824_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113826_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113838_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113828_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113830_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113828_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113834_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113832_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113834_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113832_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113840_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113836_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113838_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113836_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113840_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 15
Port_1113842_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113854_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113844_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113846_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113844_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113850_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113848_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113850_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113848_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113856_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113852_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113854_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113852_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113856_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 10
Port_1113858_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113862_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113858_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113899_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113860_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113905_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113860_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113876_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113862_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113901_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113864_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113874_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113864_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113876_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113866_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113874_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113866_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113870_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113868_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113870_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113868_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113872_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113878_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113921_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113878_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113889_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113880_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113889_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113880_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113882_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113882_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113887_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113884_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113886_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113884_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113886_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113887_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113889_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113891_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113891_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113893_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113895_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113921_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113895_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113923_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113897_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113899_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113897_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113923_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113901_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113913_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113903_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113905_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113903_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113909_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113907_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113909_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113907_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113915_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113911_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113913_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113911_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113915_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | AC 18
Port_1113925_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113927_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113925_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113931_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113927_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1114571_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113929_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1114061_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113929_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1114063_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113931_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113934_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113933_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113934_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113933_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1114063_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113933_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113946_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113937_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113951_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113937_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113941_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113939_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113955_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113939_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1114045_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113941_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113959_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113941_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113956_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113943_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1114641_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113943_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1114643_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113945_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113946_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113945_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113951_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113945_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1114643_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113949_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1114045_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113949_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1114047_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113953_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1114043_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113953_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113955_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113955_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113956_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113959_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113969_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113961_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113969_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113961_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113965_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113963_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113965_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113963_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1114003_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113965_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113967_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113967_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113977_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113969_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113971_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113971_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113975_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113973_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113975_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113973_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1114017_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113977_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113987_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113979_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113989_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113979_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113983_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113981_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113983_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113981_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113985_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113987_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
Port_1113989_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | AF 4
