Properties of the parts of a building model (IFC4), part 19 of 21

# IfcPipeSegment: Pipe Types:D2020-PVC.S (1027)
Name (Pipe Types:D2020-PVC.S:...) | In | InvertElevation (m) | Length (m) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Group
1075133 | Nivel 1 | -0.637984 | 0.0497261 | 0.00285724 | 0.00942313 | AR-DOM 4
1075141 | Nivel 1 | -0.684374 | 1.01496 | 0.0102593 | 0.364457 | AR-DOM 4
1075154 | Nivel 1 | -0.664537 | 0.482793 | 0.0102593 | 0.173363 | AR-DOM 4
1075157 | Nivel 1 | -0.63647 | 0.66647 | 0.00285724 | 0.126297 | AR-DOM 4
1075161 | Nivel 1 | -0.685688 | 0.186618 | 0.0102593 | 0.0670116 | AR-DOM 4
1075167 | Nivel 1 | -0.553663 | 0.468631 | 0.00285724 | 0.088806 | AR-DOM 4
1075171 | Nivel 1 | -0.0671417 | 0.137912 | 0.00285724 | 0.0261344 | AR-DOM 4
1075177 | Nivel 1 | 0.00591771 | 0.548032 | 0.00285724 | 0.103853 | AR-DOM 4
1075179 | Nivel 1 | 0.57231 | 0.0439524 | 0.00285724 | 0.00832901 | AR-DOM 4
1075185 | Nivel 1 | -0.57648 | 0.496307 | 0.00285724 | 0.0940505 | AR-DOM 4
1075189 | Nivel 1 | -0.060858 | 0.116819 | 0.00285724 | 0.0221372 | AR-DOM 4
1075193 | Nivel 1 | 0.013246 | 0.540704 | 0.00285724 | 0.102464 | AR-DOM 4
1075197 | Nivel 1 | 0.572991 | 0.0539517 | 0.00285724 | 0.0102239 | AR-DOM 4
1075205 | Nivel 1 | -0.561958 | 0.470908 | 0.00285724 | 0.0892375 | AR-DOM 4
1075207 | Nivel 1 | -0.0720094 | 0.131168 | 0.00285724 | 0.0248565 | AR-DOM 4
1075211 | Nivel 1 | 0.00216633 | 0.551784 | 0.00285724 | 0.104563 | AR-DOM 4
1075215 | Nivel 1 | 0.57236 | 0.0339502 | 0.00285724 | 0.0064336 | AR-DOM 4
1075221 | Nivel 1 | -0.631047 | 0.185913 | 0.00285724 | 0.0352306 | AR-DOM 4
1075224 | Nivel 1 | -0.632901 | 0.196232 | 0.00285724 | 0.037186 | AR-DOM 4
1075227 | Nivel 1 | -0.623333 | 0.862681 | 0.00285724 | 0.163479 | AR-DOM 4
1075231 | Nivel 1 | -0.618162 | 0.0495457 | 0.00285724 | 0.00938895 | AR-DOM 4
1075233 | Nivel 1 | -0.617724 | 0.213777 | 0.00285724 | 0.0405109 | AR-DOM 4
1075237 | Nivel 1 | -0.543309 | 0.446449 | 0.00285724 | 0.0846026 | AR-DOM 4
1075241 | Nivel 1 | -0.0778187 | 0.117908 | 0.00285724 | 0.0223437 | AR-DOM 4
1075245 | Nivel 1 | -0.00370926 | 0.557659 | 0.00285724 | 0.105677 | AR-DOM 4
1075249 | Nivel 1 | 0.57226 | 0.0539502 | 0.00285724 | 0.0102236 | AR-DOM 4
1075257 | Nivel 1 | -0.678139 | 0.14554 | 0.0102593 | 0.052261 | AR-DOM 4
1075259 | Nivel 1 | -0.649697 | 0.162287 | 0.00285724 | 0.0307535 | AR-DOM 4
1075262 | Nivel 1 | -0.676251 | 0.384777 | 0.0102593 | 0.138167 | AR-DOM 4
1075265 | Nivel 1 | -0.642016 | 0.824214 | 0.00285724 | 0.156189 | AR-DOM 4
1075269 | Nivel 1 | -0.637028 | 0.0637469 | 0.00285724 | 0.0120801 | AR-DOM 4
1075271 | Nivel 1 | -0.636516 | 0.207601 | 0.00285724 | 0.0393405 | AR-DOM 4
1075275 | Nivel 1 | -0.642016 | 0.123655 | 0.00285724 | 0.0234327 | AR-DOM 4
1075278 | Nivel 1 | -0.644553 | 0.332338 | 0.00285724 | 0.0629784 | AR-DOM 4
1075281 | Nivel 1 | -0.641231 | 0.760987 | 0.00285724 | 0.144208 | AR-DOM 4
1075285 | Nivel 1 | -0.637033 | 0.561007 | 0.00285724 | 0.106311 | AR-DOM 4
1075287 | Nivel 1 | -0.634026 | 0.161651 | 0.00285724 | 0.0306331 | AR-DOM 4
1075291 | Nivel 1 | -0.633028 | 0.205228 | 0.00285724 | 0.0388908 | AR-DOM 4
1075297 | Nivel 1 | -0.618163 | 0.491269 | 0.00285724 | 0.0930958 | AR-DOM 4
1075299 | Nivel 1 | -0.61552 | 0.243502 | 0.00285724 | 0.0461438 | AR-DOM 4
1075303 | Nivel 1 | -0.614113 | 0.162262 | 0.00285724 | 0.0307488 | AR-DOM 4
1075307 | Nivel 1 | -0.623333 | 0.161629 | 0.00285724 | 0.0306288 | AR-DOM 4
1075310 | Nivel 1 | -0.625892 | 0.33708 | 0.00285724 | 0.0638769 | AR-DOM 4
1075321 | Nivel 1 | -0.636161 | 0.666161 | 0.00285724 | 0.126238 | AR-DOM 4
1075325 | Nivel 1 | -0.622335 | 0.8655 | 0.00285724 | 0.164013 | AR-DOM 4
1075327 | Nivel 1 | -0.616853 | 0.646853 | 0.00285724 | 0.122579 | AR-DOM 4
1075331 | Nivel 1 | -0.539876 | 0.435698 | 0.00285724 | 0.0825652 | AR-DOM 4
1075335 | Nivel 1 | -0.0851368 | 0.102086 | 0.00285724 | 0.0193453 | AR-DOM 4
1075341 | Nivel 1 | -0.558482 | 0.462082 | 0.00285724 | 0.087565 | AR-DOM 4
1075345 | Nivel 1 | -0.0773594 | 0.133841 | 0.00285724 | 0.0253631 | AR-DOM 4
1075349 | Nivel 1 | -0.00317039 | 0.555171 | 0.00285724 | 0.105205 | AR-DOM 4
1075353 | Nivel 1 | 0.570411 | 0.0339439 | 0.00285724 | 0.00643239 | AR-DOM 4
1075359 | Nivel 1 | -0.0111066 | 0.574733 | 0.00285724 | 0.108912 | AR-DOM 4
1075361 | Nivel 1 | 0.582037 | 0.033945 | 0.00285724 | 0.00643261 | AR-DOM 4
1075873 | Nivel 1 | -0.715274 | 0.209587 | 0.0102593 | 0.0752592 | AR-DOM 4
1075975 | Nivel 1 | -0.731624 | 2.69923 | 0.0102593 | 0.96925 | AR-DOM 4
1076021 | Nivel 1 | -0.71664 | 0.197458 | 0.0102593 | 0.070904 | AR-DOM 4
1076161 | Nivel 1 | -0.71664 | 0.666102 | 0.0102593 | 0.239187 | AR-DOM 4
1076169 | Nivel 1 | -0.712928 | 5.39292 | 0.0102593 | 1.93651 | AR-DOM 4
1076668 | Nivel 2 | -0.791632 | 0.204626 | 0.0102593 | 0.0734781 | AR-DOM 1
1076751 | Nivel 1 | -0.794726 | 0.541146 | 0.0102593 | 0.194317 | AR-DOM 1
1076921 | Nivel 2 | -0.798002 | 0.709627 | 0.0102593 | 0.254816 | AR-DOM 1
1077380 | Nivel 1 | -0.799085 | 0.791095 | 0.0102593 | 0.28407 | AR-DOM 1
1078163 | Nivel 1 | -0.799082 | 0.130871 | 0.0102593 | 0.0469938 | AR-DOM 1
1078290 | Nivel 1 | -0.815984 | 3.07282 | 0.0102593 | 1.1034 | AR-DOM 1
1078335 | Nivel 1 | -0.818275 | 0.381798 | 0.0102593 | 0.137098 | AR-DOM 1
1078376 | Nivel 1 | -0.850076 | 6.21197 | 0.0102593 | 2.23062 | AR-DOM 1
1078537 | Nivel 1 | -0.788359 | 0.540213 | 0.0102593 | 0.193982 | AR-DOM 1
1078541 | Nivel 2 | -0.791676 | 0.709336 | 0.0102593 | 0.254711 | AR-DOM 1
1078547 | Nivel 1 | -0.792718 | 0.791117 | 0.0102593 | 0.284078 | AR-DOM 1
1078550 | Nivel 1 | -0.792715 | 0.131079 | 0.0102593 | 0.0470682 | AR-DOM 1
1078553 | Nivel 1 | -0.816661 | 4.4774 | 0.0102593 | 1.60776 | AR-DOM 1
1078744 | Nivel 2 | -0.785264 | 0.204704 | 0.0102593 | 0.073506 | AR-DOM 1
1080990 | Nivel 1 | -0.672843 | 0.148132 | 0.0102593 | 0.053192 | AR-DOM 4
1081036 | Nivel 1 | -0.644389 | 0.0711947 | 0.00285724 | 0.0134915 | AR-DOM 4
1081482 | Nivel 1 | -0.633054 | 0.12729 | 0.00285724 | 0.0241216 | AR-DOM 4
1081491 | Nivel 1 | -0.63396 | 0.037181 | 0.00285724 | 0.00704583 | AR-DOM 4
1081988 | Nivel 1 | -0.635054 | 0.083282 | 0.00285724 | 0.015782 | AR-DOM 4
1081999 | Nivel 1 | -0.636274 | 0.069262 | 0.00285724 | 0.0131252 | AR-DOM 4
1082197 | Nivel 1 | -0.675218 | 0.118257 | 0.0102593 | 0.0424642 | AR-DOM 4
1082256 | Nivel 1 | -0.646893 | 0.109058 | 0.00285724 | 0.0206665 | AR-DOM 4
1082875 | Nivel 1 | -0.648305 | 0.117118 | 0.00285724 | 0.0221939 | AR-DOM 4
1082892 | Nivel 1 | -0.651095 | 0.383165 | 0.00285724 | 0.0726101 | AR-DOM 4
1082981 | Nivel 1 | -0.629711 | 0.180062 | 0.00285724 | 0.0341219 | AR-DOM 4
1082990 | Nivel 1 | -0.632316 | 0.346418 | 0.00285724 | 0.0656465 | AR-DOM 4
1083127 | Nivel 1 | -0.646087 | 0.10784 | 0.00285724 | 0.0204357 | AR-DOM 4
1083136 | Nivel 1 | -0.648695 | 0.346609 | 0.00285724 | 0.0656828 | AR-DOM 4
1083260 | Nivel 1 | -0.627504 | 0.177773 | 0.00285724 | 0.0336882 | AR-DOM 4
1083269 | Nivel 1 | -0.629928 | 0.310103 | 0.00285724 | 0.0587648 | AR-DOM 4
1087894 | Nivel 1 | -0.0769567 | 0.628878 | 0.00285724 | 0.119173 | AR-DOM 4
1087907 | Nivel 1 | 0.570732 | 0.03895 | 0.00285724 | 0.00738106 | AR-DOM 4
1089060 | Nivel 1 | -0.150246 | 0.211105 | 0.00285724 | 0.0400046 | AR-DOM 4
1091288 | Nivel 2 | -0.643471 | 2.15489 | 0.0102593 | 0.773787 | AR-DOM 1
1091971 | Nivel 2 | 4.71977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1091973 | Nivel 2 | 4.71914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1091977 | Nivel 2 | 4.71484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1091981 | Nivel 3 | 4.71416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1091985 | Nivel 3 | 4.71216 | 0.360417 | 0.00285724 | 0.0682993 | AR-DOM 1
1091989 | Nivel 3 | 4.53095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1091991 | Nivel 3 | 4.53019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1091997 | Nivel 3 | 4.52304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1092003 | Nivel 3 | 4.5201 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1092005 | Nivel 3 | 4.52195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1092008 | Nivel 3 | 4.52231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1092011 | Nivel 3 | 4.52366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1092013 | Nivel 3 | 4.52924 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1092016 | Nivel 3 | 4.52924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1092019 | Nivel 3 | 4.52971 | 0.048465 | 0.00285724 | 0.00918416 | AR-DOM 1
1092021 | Nivel 3 | 4.52941 | 0.200586 | 0.0102593 | 0.0720271 | AR-DOM 1
1092025 | Nivel 3 | 4.37722 | 0.186919 | 0.0102593 | 0.0671196 | AR-DOM 1
1092029 | Nivel 3 | 5.29498 | 0.916438 | 0.0102593 | 0.329078 | AR-DOM 1
1092035 | Nivel 3 | 4.7053 | 1.2806 | 0.00285724 | 0.242675 | AR-DOM 1
1092043 | Nivel 3 | 4.07681 | 0.609451 | 0.00285724 | 0.115492 | AR-DOM 1
1092047 | Nivel 3 | 4.26437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1092049 | Nivel 3 | 4.09076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1092053 | Nivel 3 | 5.1832 | 0.348021 | 0.00285724 | 0.0659502 | AR-DOM 1
1092058 | Nivel 3 | 4.92664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1092061 | Nivel 3 | 5.18626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1092068 | Nivel 3 | 4.57177 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1092071 | Nivel 3 | 4.84949 | 0.0113382 | 0.00285724 | 0.0021486 | AR-DOM 1; VENT 1
1092077 | Nivel 3 | 4.52195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1092079 | Nivel 3 | 4.52362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1092087 | Nivel 3 | 4.60598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1092089 | Nivel 3 | 5.17276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1092095 | Nivel 3 | 4.1899 | 0.0273629 | 0.00285724 | 0.00518529 | AR-DOM 1
1092098 | Nivel 3 | 4.30168 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1092101 | Nivel 3 | 4.19021 | 0.1618 | 0.00285714 | 0.0306612 | AR-DOM 1
1092111 | Nivel 3 | 4.53109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1092113 | Nivel 2 | 4.79432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1092117 | Nivel 2 | 5.27234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1092123 | Nivel 3 | 4.6121 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1092127 | Nivel 3 | 4.68653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1092133 | Nivel 3 | 5.47611 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1092135 | Nivel 3 | 5.41644 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1092380 | Nivel 3 | 7.06977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1092382 | Nivel 3 | 7.06914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1092386 | Nivel 3 | 7.06484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1092390 | Nivel 4 | 7.06416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1092394 | Nivel 4 | 7.06216 | 0.360417 | 0.00285724 | 0.0682993 | AR-DOM 1
1092398 | Nivel 4 | 6.88095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1092400 | Nivel 4 | 6.88019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1092406 | Nivel 4 | 6.87304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1092412 | Nivel 4 | 6.8701 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1092414 | Nivel 4 | 6.87195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1092417 | Nivel 4 | 6.87231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1092420 | Nivel 4 | 6.87366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1092422 | Nivel 4 | 6.87924 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1092425 | Nivel 4 | 6.87924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1092428 | Nivel 4 | 6.87971 | 0.048465 | 0.00285724 | 0.00918416 | AR-DOM 1
1092430 | Nivel 4 | 6.87941 | 0.200586 | 0.0102593 | 0.0720271 | AR-DOM 1
1092434 | Nivel 4 | 6.72722 | 0.186919 | 0.0102593 | 0.0671196 | AR-DOM 1
1092444 | Nivel 4 | 7.0553 | 1.2806 | 0.00285724 | 0.242675 | AR-DOM 1
1092452 | Nivel 4 | 6.42681 | 0.609451 | 0.00285724 | 0.115492 | AR-DOM 1
1092456 | Nivel 4 | 6.61437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1092458 | Nivel 4 | 6.44076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1092462 | Nivel 4 | 7.5332 | 0.348021 | 0.00285724 | 0.0659502 | AR-DOM 1
1092467 | Nivel 4 | 7.27664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1092470 | Nivel 4 | 7.53626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1092477 | Nivel 4 | 6.92177 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1092480 | Nivel 4 | 7.19949 | 0.0113382 | 0.00285724 | 0.0021486 | AR-DOM 1; VENT 1
1092486 | Nivel 4 | 6.87195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1092488 | Nivel 4 | 6.87362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1092496 | Nivel 4 | 6.95598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1092498 | Nivel 4 | 7.52276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1092504 | Nivel 4 | 6.5399 | 0.0273629 | 0.00285724 | 0.00518529 | AR-DOM 1
1092507 | Nivel 4 | 6.65168 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1092510 | Nivel 4 | 6.54021 | 0.1618 | 0.00285714 | 0.0306612 | AR-DOM 1
1092520 | Nivel 4 | 6.88109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1092522 | Nivel 3 | 7.14432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1092526 | Nivel 3 | 7.62234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1092532 | Nivel 4 | 6.9621 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1092536 | Nivel 4 | 7.03653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1092542 | Nivel 4 | 7.82611 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1092544 | Nivel 4 | 7.76644 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1092788 | Nivel 4 | 9.41977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1092790 | Nivel 4 | 9.41914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1092794 | Nivel 4 | 9.41484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1092798 | Nivel 5 | 9.41416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1092802 | Nivel 5 | 9.41216 | 0.360417 | 0.00285724 | 0.0682993 | AR-DOM 1
1092806 | Nivel 5 | 9.23095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1092808 | Nivel 5 | 9.23019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1092814 | Nivel 5 | 9.22304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1092820 | Nivel 5 | 9.2201 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1092822 | Nivel 5 | 9.22195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1092825 | Nivel 5 | 9.22231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1092828 | Nivel 5 | 9.22366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1092830 | Nivel 5 | 9.22924 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1092833 | Nivel 5 | 9.22924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1092836 | Nivel 5 | 9.22971 | 0.048465 | 0.00285724 | 0.00918416 | AR-DOM 1
1092838 | Nivel 5 | 9.22941 | 0.200586 | 0.0102593 | 0.0720271 | AR-DOM 1
1092842 | Nivel 5 | 9.07722 | 0.186919 | 0.0102593 | 0.0671196 | AR-DOM 1
1092846 | Nivel 5 | 9.99498 | 0.916438 | 0.0102593 | 0.329078 | AR-DOM 1
1092852 | Nivel 5 | 9.4053 | 1.2806 | 0.00285724 | 0.242675 | AR-DOM 1
1092860 | Nivel 5 | 8.77681 | 0.609451 | 0.00285724 | 0.115492 | AR-DOM 1
1092864 | Nivel 5 | 8.96437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1092866 | Nivel 5 | 8.79076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1092870 | Nivel 5 | 9.8832 | 0.348021 | 0.00285724 | 0.0659502 | AR-DOM 1
1092875 | Nivel 5 | 9.62664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1092878 | Nivel 5 | 9.88626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1092885 | Nivel 5 | 9.27177 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1092888 | Nivel 5 | 9.54949 | 0.0113382 | 0.00285724 | 0.0021486 | AR-DOM 1; VENT 1
1092894 | Nivel 5 | 9.22195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1092896 | Nivel 5 | 9.22362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1092904 | Nivel 5 | 9.30598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1092906 | Nivel 5 | 9.87276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1092912 | Nivel 5 | 8.8899 | 0.0273629 | 0.00285724 | 0.00518529 | AR-DOM 1
1092915 | Nivel 5 | 9.00168 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1092918 | Nivel 5 | 8.89021 | 0.1618 | 0.00285714 | 0.0306612 | AR-DOM 1
1092928 | Nivel 5 | 9.23109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1092930 | Nivel 4 | 9.49432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1092934 | Nivel 4 | 9.97234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1092940 | Nivel 5 | 9.3121 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1092944 | Nivel 5 | 9.38653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1092950 | Nivel 5 | 10.1761 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1092952 | Nivel 5 | 10.1164 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1093128 | Nivel 5 | 7.64498 | 0.352375 | 0.0102593 | 0.126532 | AR-DOM 1
1093196 | Nivel 5 | 11.7698 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1093198 | Nivel 5 | 11.7691 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1093202 | Nivel 5 | 11.7648 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1093206 | Nivel 6 | 11.7642 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1093210 | Nivel 6 | 11.7622 | 0.360417 | 0.00285724 | 0.0682993 | AR-DOM 1
1093214 | Nivel 6 | 11.581 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1093216 | Nivel 6 | 11.5802 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1093222 | Nivel 6 | 11.573 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1093228 | Nivel 6 | 11.5701 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1093230 | Nivel 6 | 11.572 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1093233 | Nivel 6 | 11.5723 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1093236 | Nivel 6 | 11.5737 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1093238 | Nivel 6 | 11.5792 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1093241 | Nivel 6 | 11.5792 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1093244 | Nivel 6 | 11.5797 | 0.048465 | 0.00285724 | 0.00918416 | AR-DOM 1
1093246 | Nivel 6 | 11.5794 | 0.200586 | 0.0102593 | 0.0720271 | AR-DOM 1
1093250 | Nivel 6 | 11.4272 | 0.186919 | 0.0102593 | 0.0671196 | AR-DOM 1
1093260 | Nivel 6 | 11.7553 | 1.2806 | 0.00285724 | 0.242675 | AR-DOM 1
1093268 | Nivel 6 | 11.1268 | 0.609451 | 0.00285724 | 0.115492 | AR-DOM 1
1093272 | Nivel 6 | 11.3144 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1093274 | Nivel 6 | 11.1408 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1093278 | Nivel 6 | 12.2332 | 0.348021 | 0.00285724 | 0.0659502 | AR-DOM 1
1093283 | Nivel 6 | 11.9766 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1093286 | Nivel 6 | 12.2363 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1093293 | Nivel 6 | 11.6218 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1093296 | Nivel 6 | 11.8995 | 0.0108605 | 0.00285724 | 0.00205808 | AR-DOM 1; VENT 1
1093302 | Nivel 6 | 11.5719 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1093304 | Nivel 6 | 11.5736 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1093312 | Nivel 6 | 11.656 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1093314 | Nivel 6 | 12.2228 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1093320 | Nivel 6 | 11.2399 | 0.0273629 | 0.00285724 | 0.00518529 | AR-DOM 1
1093323 | Nivel 6 | 11.3517 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1093326 | Nivel 6 | 11.2402 | 0.1618 | 0.00285714 | 0.0306612 | AR-DOM 1
1093336 | Nivel 6 | 11.5811 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1093338 | Nivel 5 | 11.8443 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1093342 | Nivel 5 | 12.3223 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1093348 | Nivel 6 | 11.6621 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1093352 | Nivel 6 | 11.7365 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1093358 | Nivel 6 | 12.5261 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1093360 | Nivel 6 | 12.4664 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1093661 | Nivel 6 | 12.5635 | 0.157078 | 0.0102593 | 0.056404 | AR-DOM 1; VENT 1
1095250 | Nivel 1 | 2.36977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1095252 | Nivel 1 | 2.36914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1095256 | Nivel 1 | 2.36484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1095260 | Nivel 2 | 2.36416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1095264 | Nivel 2 | 2.36216 | 0.360417 | 0.00285724 | 0.0682993 | AR-DOM 1
1095268 | Nivel 2 | 2.18095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1095270 | Nivel 2 | 2.18019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1095276 | Nivel 2 | 2.17304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1095282 | Nivel 2 | 2.1701 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1095284 | Nivel 2 | 2.17195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1095287 | Nivel 2 | 2.17231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1095290 | Nivel 2 | 2.17366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1095292 | Nivel 2 | 2.17924 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1095295 | Nivel 2 | 2.17924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1095298 | Nivel 2 | 2.17948 | 0.0483453 | 0.00285724 | 0.00916148 | AR-DOM 1
1095300 | Nivel 2 | 2.17941 | 0.200585 | 0.0102593 | 0.0720269 | AR-DOM 1
1095304 | Nivel 2 | 2.02722 | 0.187035 | 0.0102593 | 0.0671614 | AR-DOM 1
1095308 | Nivel 2 | 2.94498 | 0.916438 | 0.0102593 | 0.329078 | AR-DOM 1
1095314 | Nivel 2 | 2.3553 | 1.28058 | 0.00285724 | 0.242672 | AR-DOM 1
1095322 | Nivel 2 | 1.72681 | 0.609488 | 0.00285724 | 0.115498 | AR-DOM 1
1095326 | Nivel 2 | 1.91437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1095328 | Nivel 2 | 1.74076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1095332 | Nivel 2 | 2.8332 | 0.347973 | 0.00285724 | 0.0659413 | AR-DOM 1
1095337 | Nivel 2 | 2.57664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1095340 | Nivel 2 | 2.83626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1095347 | Nivel 2 | 2.22177 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1095350 | Nivel 2 | 2.49949 | 0.0109275 | 0.00285724 | 0.00207077 | AR-DOM 1; VENT 2
1095356 | Nivel 2 | 2.17195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1095358 | Nivel 2 | 2.17362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1095366 | Nivel 2 | 2.25598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1095368 | Nivel 2 | 2.82276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1095374 | Nivel 2 | 1.8399 | 0.027109 | 0.00285724 | 0.00513718 | AR-DOM 1
1095377 | Nivel 2 | 1.95168 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1095380 | Nivel 2 | 1.84021 | 0.16223 | 0.00285724 | 0.0307427 | AR-DOM 1
1095390 | Nivel 2 | 2.18109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1095392 | Nivel 1 | 2.44432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1095396 | Nivel 1 | 2.92234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1095402 | Nivel 2 | 2.2621 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1095406 | Nivel 2 | 2.33653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1095412 | Nivel 2 | 3.12611 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1095414 | Nivel 2 | 3.06644 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1095420 | Nivel 2 | -0.639627 | 2.15105 | 0.0102593 | 0.772407 | AR-DOM 1
1095424 | Nivel 2 | 4.71977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1095426 | Nivel 2 | 4.71914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1095430 | Nivel 2 | 4.71484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1095434 | Nivel 3 | 4.71416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1095438 | Nivel 3 | 4.71216 | 0.360417 | 0.00285724 | 0.0682993 | AR-DOM 1
1095442 | Nivel 3 | 4.53095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1095444 | Nivel 3 | 4.53019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1095450 | Nivel 3 | 4.52304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1095456 | Nivel 3 | 4.5201 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1095458 | Nivel 3 | 4.52195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1095461 | Nivel 3 | 4.52231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1095464 | Nivel 3 | 4.52366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1095466 | Nivel 3 | 4.52924 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1095469 | Nivel 3 | 4.52924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1095472 | Nivel 3 | 4.52971 | 0.048465 | 0.00285724 | 0.00918416 | AR-DOM 1
1095474 | Nivel 3 | 4.52941 | 0.200586 | 0.0102593 | 0.0720271 | AR-DOM 1
1095478 | Nivel 3 | 4.37722 | 0.187081 | 0.0102593 | 0.0671779 | AR-DOM 1
1095482 | Nivel 3 | 5.29498 | 0.916438 | 0.0102593 | 0.329078 | AR-DOM 1
1095488 | Nivel 3 | 4.7053 | 1.28058 | 0.00285724 | 0.242672 | AR-DOM 1
1095496 | Nivel 3 | 4.07681 | 0.609488 | 0.00285724 | 0.115498 | AR-DOM 1
1095500 | Nivel 3 | 4.26437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1095502 | Nivel 3 | 4.09076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1095506 | Nivel 3 | 5.1832 | 0.347925 | 0.00285724 | 0.0659322 | AR-DOM 1
1095511 | Nivel 3 | 4.92664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1095514 | Nivel 3 | 5.18626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1095521 | Nivel 3 | 4.57177 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1095524 | Nivel 3 | 4.84949 | 0.0109953 | 0.00285724 | 0.00208362 | AR-DOM 1; VENT 2
1095530 | Nivel 3 | 4.52195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1095532 | Nivel 3 | 4.52362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1095540 | Nivel 3 | 4.60598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1095542 | Nivel 3 | 5.17276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1095548 | Nivel 3 | 4.1899 | 0.0271118 | 0.00285724 | 0.00513771 | AR-DOM 1
1095551 | Nivel 3 | 4.30168 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1095554 | Nivel 3 | 4.19021 | 0.162276 | 0.00285724 | 0.0307514 | AR-DOM 1
1095564 | Nivel 3 | 4.53109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1095566 | Nivel 2 | 4.79432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1095570 | Nivel 2 | 5.27234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1095576 | Nivel 3 | 4.6121 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1095580 | Nivel 3 | 4.68653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1095586 | Nivel 3 | 5.47611 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1095588 | Nivel 3 | 5.41644 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1095594 | Nivel 3 | 7.06977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1095596 | Nivel 3 | 7.06914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1095600 | Nivel 3 | 7.06484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1095604 | Nivel 4 | 7.06416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1095608 | Nivel 4 | 7.06216 | 0.360417 | 0.00285724 | 0.0682993 | AR-DOM 1
1095612 | Nivel 4 | 6.88095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1095614 | Nivel 4 | 6.88019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1095620 | Nivel 4 | 6.87304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1095626 | Nivel 4 | 6.8701 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1095628 | Nivel 4 | 6.87195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1095631 | Nivel 4 | 6.87231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1095634 | Nivel 4 | 6.87366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1095636 | Nivel 4 | 6.87924 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1095639 | Nivel 4 | 6.87924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1095642 | Nivel 4 | 6.87971 | 0.048465 | 0.00285724 | 0.00918416 | AR-DOM 1
1095644 | Nivel 4 | 6.87941 | 0.200586 | 0.0102593 | 0.0720271 | AR-DOM 1
1095648 | Nivel 4 | 6.72722 | 0.187081 | 0.0102593 | 0.0671779 | AR-DOM 1
1095656 | Nivel 4 | 7.05534 | 1.28046 | 0.00285724 | 0.242648 | AR-DOM 1
1095664 | Nivel 4 | 6.42681 | 0.609488 | 0.00285724 | 0.115498 | AR-DOM 1
1095668 | Nivel 4 | 6.61437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1095670 | Nivel 4 | 6.44076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1095674 | Nivel 4 | 7.5332 | 0.347925 | 0.00285724 | 0.0659322 | AR-DOM 1
1095679 | Nivel 4 | 7.27664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1095682 | Nivel 4 | 7.53626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1095689 | Nivel 4 | 6.92177 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1095692 | Nivel 4 | 7.19949 | 0.0109953 | 0.00285724 | 0.00208362 | AR-DOM 1; VENT 2
1095698 | Nivel 4 | 6.87195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1095700 | Nivel 4 | 6.87362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1095708 | Nivel 4 | 6.95598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1095710 | Nivel 4 | 7.52276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1095716 | Nivel 4 | 6.5399 | 0.0271118 | 0.00285724 | 0.00513771 | AR-DOM 1
1095719 | Nivel 4 | 6.65168 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1095722 | Nivel 4 | 6.54021 | 0.162276 | 0.00285724 | 0.0307514 | AR-DOM 1
1095732 | Nivel 4 | 6.88109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1095734 | Nivel 3 | 7.14432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1095738 | Nivel 3 | 7.62234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1095744 | Nivel 4 | 6.9621 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1095748 | Nivel 4 | 7.03653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1095754 | Nivel 4 | 7.82611 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1095756 | Nivel 4 | 7.76644 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1095762 | Nivel 4 | 9.41977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1095764 | Nivel 4 | 9.41914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1095768 | Nivel 4 | 9.41484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1095772 | Nivel 5 | 9.41416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1095776 | Nivel 5 | 9.41216 | 0.360417 | 0.00285724 | 0.0682993 | AR-DOM 1
1095780 | Nivel 5 | 9.23095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1095782 | Nivel 5 | 9.23019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1095788 | Nivel 5 | 9.22304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1095794 | Nivel 5 | 9.2201 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1095796 | Nivel 5 | 9.22195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1095799 | Nivel 5 | 9.22231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1095802 | Nivel 5 | 9.22366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1095804 | Nivel 5 | 9.22924 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1095807 | Nivel 5 | 9.22924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1095810 | Nivel 5 | 9.22971 | 0.048465 | 0.00285724 | 0.00918416 | AR-DOM 1
1095812 | Nivel 5 | 9.22941 | 0.200586 | 0.0102593 | 0.0720271 | AR-DOM 1
1095816 | Nivel 5 | 9.07722 | 0.187081 | 0.0102593 | 0.0671779 | AR-DOM 1
1095820 | Nivel 5 | 9.99498 | 0.916438 | 0.0102593 | 0.329078 | AR-DOM 1
1095826 | Nivel 5 | 9.40534 | 1.28046 | 0.00285724 | 0.242648 | AR-DOM 1
1095834 | Nivel 5 | 8.77681 | 0.609488 | 0.00285724 | 0.115498 | AR-DOM 1
1095838 | Nivel 5 | 8.96437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1095840 | Nivel 5 | 8.79076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1095844 | Nivel 5 | 9.8832 | 0.347925 | 0.00285724 | 0.0659322 | AR-DOM 1
1095849 | Nivel 5 | 9.62664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1095852 | Nivel 5 | 9.88626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1095859 | Nivel 5 | 9.27177 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1095862 | Nivel 5 | 9.54949 | 0.0109953 | 0.00285724 | 0.00208362 | AR-DOM 1; VENT 2
1095868 | Nivel 5 | 9.22195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1095870 | Nivel 5 | 9.22362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1095878 | Nivel 5 | 9.30598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1095880 | Nivel 5 | 9.87276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1095886 | Nivel 5 | 8.8899 | 0.0271118 | 0.00285724 | 0.00513771 | AR-DOM 1
1095889 | Nivel 5 | 9.00168 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1095892 | Nivel 5 | 8.89021 | 0.162276 | 0.00285724 | 0.0307514 | AR-DOM 1
1095902 | Nivel 5 | 9.23109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1095904 | Nivel 4 | 9.49432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1095908 | Nivel 4 | 9.97234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1095914 | Nivel 5 | 9.3121 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1095918 | Nivel 5 | 9.38653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1095924 | Nivel 5 | 10.1761 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1095926 | Nivel 5 | 10.1164 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1095932 | Nivel 5 | 7.64498 | 0.352375 | 0.0102593 | 0.126532 | AR-DOM 1
1095934 | Nivel 5 | 11.7698 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1095936 | Nivel 5 | 11.7691 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1095940 | Nivel 5 | 11.7648 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1095944 | Nivel 6 | 11.7642 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1095948 | Nivel 6 | 11.7622 | 0.360417 | 0.00285724 | 0.0682993 | AR-DOM 1
1095952 | Nivel 6 | 11.581 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1095954 | Nivel 6 | 11.5802 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1095960 | Nivel 6 | 11.573 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1095966 | Nivel 6 | 11.5701 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1095968 | Nivel 6 | 11.572 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1095971 | Nivel 6 | 11.5723 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1095974 | Nivel 6 | 11.5737 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1095976 | Nivel 6 | 11.5792 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1095979 | Nivel 6 | 11.5792 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1095982 | Nivel 6 | 11.5797 | 0.048465 | 0.00285724 | 0.00918416 | AR-DOM 1
1095984 | Nivel 6 | 11.5794 | 0.200586 | 0.0102593 | 0.0720271 | AR-DOM 1
1095988 | Nivel 6 | 11.4272 | 0.187081 | 0.0102593 | 0.0671779 | AR-DOM 1
1095996 | Nivel 6 | 11.7553 | 1.28046 | 0.00285724 | 0.242648 | AR-DOM 1
1096004 | Nivel 6 | 11.1268 | 0.609488 | 0.00285724 | 0.115498 | AR-DOM 1
1096008 | Nivel 6 | 11.3144 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1096010 | Nivel 6 | 11.1408 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1096014 | Nivel 6 | 12.2332 | 0.347925 | 0.00285724 | 0.0659322 | AR-DOM 1
1096019 | Nivel 6 | 11.9766 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1096022 | Nivel 6 | 12.2363 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1096027 | Nivel 6 | 11.6218 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1096030 | Nivel 6 | 11.8995 | 0.0109953 | 0.00285724 | 0.00208362 | AR-DOM 1; VENT 2
1096036 | Nivel 6 | 11.5719 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1096038 | Nivel 6 | 11.5736 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1096046 | Nivel 6 | 11.656 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1096048 | Nivel 6 | 12.2228 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1096054 | Nivel 6 | 11.2399 | 0.0271118 | 0.00285724 | 0.00513771 | AR-DOM 1
1096057 | Nivel 6 | 11.3517 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1096060 | Nivel 6 | 11.2402 | 0.162276 | 0.00285724 | 0.0307514 | AR-DOM 1
1096070 | Nivel 6 | 11.5811 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1096072 | Nivel 5 | 11.8443 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1096076 | Nivel 5 | 12.3223 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1096082 | Nivel 6 | 11.6621 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1096086 | Nivel 6 | 11.7365 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1096092 | Nivel 6 | 12.5261 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1096094 | Nivel 6 | 12.4664 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1096100 | Nivel 6 | 12.5635 | 0.157092 | 0.0102593 | 0.0564093 | AR-DOM 1; VENT 2
1096992 | Nivel 1 | 2.36977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1096994 | Nivel 1 | 2.36914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1096998 | Nivel 1 | 2.36484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1097002 | Nivel 2 | 2.36416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1097006 | Nivel 2 | 2.36216 | 0.360417 | 0.00285724 | 0.0682993 | AR-DOM 1
1097010 | Nivel 2 | 2.18095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1097012 | Nivel 2 | 2.18019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1097018 | Nivel 2 | 2.17304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1097024 | Nivel 2 | 2.1701 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1097026 | Nivel 2 | 2.17195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1097029 | Nivel 2 | 2.17231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1097032 | Nivel 2 | 2.17366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1097034 | Nivel 2 | 2.17924 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1097037 | Nivel 2 | 2.17924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1097040 | Nivel 2 | 2.17948 | 0.0483453 | 0.00285724 | 0.00916148 | AR-DOM 1
1097042 | Nivel 2 | 2.17941 | 0.200585 | 0.0102593 | 0.0720269 | AR-DOM 1
1097046 | Nivel 2 | 2.02686 | 0.187018 | 0.0102593 | 0.067155 | AR-DOM 1
1097050 | Nivel 2 | 2.94498 | 0.916438 | 0.0102593 | 0.329078 | AR-DOM 1
1097056 | Nivel 2 | 2.3553 | 1.28049 | 0.00285724 | 0.242654 | AR-DOM 1
1097064 | Nivel 2 | 1.72681 | 0.609451 | 0.00285724 | 0.115492 | AR-DOM 1
1097068 | Nivel 2 | 1.91437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1097070 | Nivel 2 | 1.74076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1097074 | Nivel 2 | 2.8332 | 0.347953 | 0.00285724 | 0.0659373 | AR-DOM 1
1097079 | Nivel 2 | 2.57664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1097082 | Nivel 2 | 2.83626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1097089 | Nivel 2 | 2.22141 | 0.123211 | 0.0102593 | 0.044243 | AR-DOM 1
1097092 | Nivel 2 | 2.49915 | 0.0109685 | 0.00285724 | 0.00207854 | AR-DOM 1; VENT 3
1097098 | Nivel 2 | 2.17195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1097100 | Nivel 2 | 2.17362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1097108 | Nivel 2 | 2.25598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1097110 | Nivel 2 | 2.82276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1097116 | Nivel 2 | 1.8399 | 0.0275212 | 0.00285724 | 0.00521529 | AR-DOM 1
1097119 | Nivel 2 | 1.95168 | 0.015103 | 0.0102593 | 0.00542323 | AR-DOM 1
1097122 | Nivel 2 | 1.84021 | 0.1618 | 0.00285714 | 0.0306612 | AR-DOM 1
1097132 | Nivel 2 | 2.18109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1097134 | Nivel 1 | 2.44432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1097138 | Nivel 1 | 2.92234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1097144 | Nivel 2 | 2.2621 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1097148 | Nivel 2 | 2.33653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1097154 | Nivel 2 | 3.12611 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1097156 | Nivel 2 | 3.06644 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1097166 | Nivel 2 | 4.71977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1097168 | Nivel 2 | 4.71914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1097172 | Nivel 2 | 4.71484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1097176 | Nivel 3 | 4.71416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1097180 | Nivel 3 | 4.71216 | 0.360417 | 0.00285724 | 0.0682993 | AR-DOM 1
1097184 | Nivel 3 | 4.53095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1097186 | Nivel 3 | 4.53019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1097192 | Nivel 3 | 4.52304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1097198 | Nivel 3 | 4.5201 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1097200 | Nivel 3 | 4.52195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1097203 | Nivel 3 | 4.52231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1097206 | Nivel 3 | 4.52366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1097208 | Nivel 3 | 4.52924 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1097211 | Nivel 3 | 4.52924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1097214 | Nivel 3 | 4.52971 | 0.048465 | 0.00285724 | 0.00918416 | AR-DOM 1
1097216 | Nivel 3 | 4.52941 | 0.200586 | 0.0102593 | 0.0720271 | AR-DOM 1
1097220 | Nivel 3 | 4.37722 | 0.186786 | 0.0102593 | 0.0670717 | AR-DOM 1
1097224 | Nivel 3 | 5.29498 | 0.916438 | 0.0102593 | 0.329078 | AR-DOM 1
1097230 | Nivel 3 | 4.7053 | 1.28049 | 0.00285724 | 0.242654 | AR-DOM 1
1097238 | Nivel 3 | 4.07681 | 0.609451 | 0.00285724 | 0.115492 | AR-DOM 1
1097242 | Nivel 3 | 4.26437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1097244 | Nivel 3 | 4.09076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1097248 | Nivel 3 | 5.1832 | 0.347905 | 0.00285724 | 0.0659283 | AR-DOM 1
1097253 | Nivel 3 | 4.92664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1097256 | Nivel 3 | 5.18626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1097263 | Nivel 3 | 4.57177 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1097266 | Nivel 3 | 4.84916 | 0.0110363 | 0.00285724 | 0.00209138 | AR-DOM 1; VENT 3
1097272 | Nivel 3 | 4.52195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1097274 | Nivel 3 | 4.52362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1097282 | Nivel 3 | 4.60598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1097284 | Nivel 3 | 5.17276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1097290 | Nivel 3 | 4.1899 | 0.0273309 | 0.00285724 | 0.00517923 | AR-DOM 1
1097293 | Nivel 3 | 4.30168 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1097296 | Nivel 3 | 4.19021 | 0.161757 | 0.00285724 | 0.0306531 | AR-DOM 1
1097306 | Nivel 3 | 4.53109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1097308 | Nivel 2 | 4.79432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1097312 | Nivel 2 | 5.27234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1097318 | Nivel 3 | 4.6121 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1097322 | Nivel 3 | 4.68653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1097328 | Nivel 3 | 5.47611 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1097330 | Nivel 3 | 5.41644 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1097336 | Nivel 3 | 7.06977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1097338 | Nivel 3 | 7.06914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1097342 | Nivel 3 | 7.06484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1097346 | Nivel 4 | 7.06416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1097350 | Nivel 4 | 7.06216 | 0.360417 | 0.00285724 | 0.0682993 | AR-DOM 1
1097354 | Nivel 4 | 6.88095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1097356 | Nivel 4 | 6.88019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1097362 | Nivel 4 | 6.87304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1097368 | Nivel 4 | 6.8701 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1097370 | Nivel 4 | 6.87195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1097373 | Nivel 4 | 6.87231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1097376 | Nivel 4 | 6.87366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1097378 | Nivel 4 | 6.87924 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1097381 | Nivel 4 | 6.87924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1097384 | Nivel 4 | 6.87971 | 0.048465 | 0.00285724 | 0.00918416 | AR-DOM 1
1097386 | Nivel 4 | 6.87941 | 0.200586 | 0.0102593 | 0.0720271 | AR-DOM 1
1097390 | Nivel 4 | 6.72722 | 0.186786 | 0.0102593 | 0.0670717 | AR-DOM 1
1097398 | Nivel 4 | 7.0553 | 1.28049 | 0.00285724 | 0.242654 | AR-DOM 1
1097406 | Nivel 4 | 6.42681 | 0.609451 | 0.00285724 | 0.115492 | AR-DOM 1
1097410 | Nivel 4 | 6.61437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1097412 | Nivel 4 | 6.44076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1097416 | Nivel 4 | 7.5332 | 0.347905 | 0.00285724 | 0.0659283 | AR-DOM 1
1097421 | Nivel 4 | 7.27664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1097424 | Nivel 4 | 7.53626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1097431 | Nivel 4 | 6.92177 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1097434 | Nivel 4 | 7.19916 | 0.0110363 | 0.00285724 | 0.00209138 | AR-DOM 1; VENT 3
1097440 | Nivel 4 | 6.87195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1097442 | Nivel 4 | 6.87362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1097450 | Nivel 4 | 6.95598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1097452 | Nivel 4 | 7.52276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1097458 | Nivel 4 | 6.5399 | 0.0273309 | 0.00285724 | 0.00517923 | AR-DOM 1
1097461 | Nivel 4 | 6.65168 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1097464 | Nivel 4 | 6.54021 | 0.161757 | 0.00285724 | 0.0306531 | AR-DOM 1
1097474 | Nivel 4 | 6.88109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1097476 | Nivel 3 | 7.14432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1097480 | Nivel 3 | 7.62234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1097486 | Nivel 4 | 6.9621 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1097490 | Nivel 4 | 7.03653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1097496 | Nivel 4 | 7.82611 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1097498 | Nivel 4 | 7.76644 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1097504 | Nivel 4 | 9.41977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1097506 | Nivel 4 | 9.41914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1097510 | Nivel 4 | 9.41484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1097514 | Nivel 5 | 9.41416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1097518 | Nivel 5 | 9.41216 | 0.360417 | 0.00285724 | 0.0682993 | AR-DOM 1
1097522 | Nivel 5 | 9.23095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1097524 | Nivel 5 | 9.23019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1097530 | Nivel 5 | 9.22304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1097536 | Nivel 5 | 9.2201 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1097538 | Nivel 5 | 9.22195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1097541 | Nivel 5 | 9.22231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1097544 | Nivel 5 | 9.22366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1097546 | Nivel 5 | 9.22924 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1097549 | Nivel 5 | 9.22924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1097552 | Nivel 5 | 9.22971 | 0.048465 | 0.00285724 | 0.00918416 | AR-DOM 1
1097554 | Nivel 5 | 9.22941 | 0.200586 | 0.0102593 | 0.0720271 | AR-DOM 1
1097558 | Nivel 5 | 9.07722 | 0.186786 | 0.0102593 | 0.0670717 | AR-DOM 1
1097562 | Nivel 5 | 9.99498 | 0.916438 | 0.0102593 | 0.329078 | AR-DOM 1
1097568 | Nivel 5 | 9.4053 | 1.28049 | 0.00285724 | 0.242654 | AR-DOM 1
1097576 | Nivel 5 | 8.77681 | 0.609451 | 0.00285724 | 0.115492 | AR-DOM 1
1097580 | Nivel 5 | 8.96437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1097582 | Nivel 5 | 8.79076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1097586 | Nivel 5 | 9.8832 | 0.347905 | 0.00285724 | 0.0659283 | AR-DOM 1
1097591 | Nivel 5 | 9.62664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1097594 | Nivel 5 | 9.88626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1097601 | Nivel 5 | 9.27177 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1097604 | Nivel 5 | 9.54916 | 0.0110363 | 0.00285724 | 0.00209138 | AR-DOM 1; VENT 3
1097610 | Nivel 5 | 9.22195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1097612 | Nivel 5 | 9.22362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1097620 | Nivel 5 | 9.30598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1097622 | Nivel 5 | 9.87276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1097628 | Nivel 5 | 8.8899 | 0.0273309 | 0.00285724 | 0.00517923 | AR-DOM 1
1097631 | Nivel 5 | 9.00168 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1097634 | Nivel 5 | 8.89021 | 0.161757 | 0.00285724 | 0.0306531 | AR-DOM 1
1097644 | Nivel 5 | 9.23109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1097646 | Nivel 4 | 9.49432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1097650 | Nivel 4 | 9.97234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1097656 | Nivel 5 | 9.3121 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1097660 | Nivel 5 | 9.38653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1097666 | Nivel 5 | 10.1761 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1097668 | Nivel 5 | 10.1164 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1097674 | Nivel 5 | 7.64498 | 0.916438 | 0.0102593 | 0.329078 | AR-DOM 1
1097676 | Nivel 5 | 11.7698 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1097678 | Nivel 5 | 11.7691 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1097682 | Nivel 5 | 11.7648 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1097686 | Nivel 6 | 11.7642 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1097690 | Nivel 6 | 11.7622 | 0.360417 | 0.00285724 | 0.0682993 | AR-DOM 1
1097694 | Nivel 6 | 11.581 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1097696 | Nivel 6 | 11.5802 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1097702 | Nivel 6 | 11.573 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1097708 | Nivel 6 | 11.5701 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1097710 | Nivel 6 | 11.572 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1097713 | Nivel 6 | 11.5723 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1097716 | Nivel 6 | 11.5737 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1097718 | Nivel 6 | 11.5792 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1097721 | Nivel 6 | 11.5792 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1097724 | Nivel 6 | 11.5797 | 0.048465 | 0.00285724 | 0.00918416 | AR-DOM 1
1097726 | Nivel 6 | 11.5794 | 0.200586 | 0.0102593 | 0.0720271 | AR-DOM 1
1097730 | Nivel 6 | 11.4272 | 0.186786 | 0.0102593 | 0.0670717 | AR-DOM 1
1097738 | Nivel 6 | 11.7553 | 1.28049 | 0.00285724 | 0.242654 | AR-DOM 1
1097746 | Nivel 6 | 11.1268 | 0.609451 | 0.00285724 | 0.115492 | AR-DOM 1
1097750 | Nivel 6 | 11.3144 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1097752 | Nivel 6 | 11.1408 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1097756 | Nivel 6 | 12.2332 | 0.347905 | 0.00285724 | 0.0659283 | AR-DOM 1
1097761 | Nivel 6 | 11.9766 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1097764 | Nivel 6 | 12.2363 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1097769 | Nivel 6 | 11.6218 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1097772 | Nivel 6 | 11.8992 | 0.0110363 | 0.00285724 | 0.00209138 | AR-DOM 1; VENT 3
1097778 | Nivel 6 | 11.5719 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1097780 | Nivel 6 | 11.5736 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1097788 | Nivel 6 | 11.656 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1097790 | Nivel 6 | 12.2228 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1097796 | Nivel 6 | 11.2399 | 0.0273309 | 0.00285724 | 0.00517923 | AR-DOM 1
1097799 | Nivel 6 | 11.3517 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1097802 | Nivel 6 | 11.2402 | 0.161757 | 0.00285724 | 0.0306531 | AR-DOM 1
1097812 | Nivel 6 | 11.5811 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1097814 | Nivel 5 | 11.8443 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1097818 | Nivel 5 | 12.3223 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1097824 | Nivel 6 | 11.6621 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1097828 | Nivel 6 | 11.7365 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1097834 | Nivel 6 | 12.5261 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1097836 | Nivel 6 | 12.4664 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1097842 | Nivel 6 | 12.345 | 0.375596 | 0.0102593 | 0.13487 | AR-DOM 1
1097862 | Nivel 1 | 2.36977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1097864 | Nivel 1 | 2.36914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1097868 | Nivel 1 | 2.36484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1097872 | Nivel 2 | 2.36416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1097876 | Nivel 2 | 2.3622 | 0.361293 | 0.00285724 | 0.0684652 | AR-DOM 1
1097880 | Nivel 2 | 2.18095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1097882 | Nivel 2 | 2.18019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1097888 | Nivel 2 | 2.17304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1097894 | Nivel 2 | 2.1701 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1097896 | Nivel 2 | 2.17195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1097899 | Nivel 2 | 2.17231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1097902 | Nivel 2 | 2.17366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1097904 | Nivel 2 | 2.17924 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1097907 | Nivel 2 | 2.17924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1097910 | Nivel 2 | 2.17971 | 0.048465 | 0.00285724 | 0.00918416 | AR-DOM 1
1097912 | Nivel 2 | 2.17941 | 0.200589 | 0.0102593 | 0.0720282 | AR-DOM 1
1097916 | Nivel 2 | 2.02722 | 0.186096 | 0.0102593 | 0.0668242 | AR-DOM 1
1097920 | Nivel 2 | 2.94498 | 0.916438 | 0.0102593 | 0.329078 | AR-DOM 1
1097926 | Nivel 2 | 2.35534 | 1.28051 | 0.00285724 | 0.242658 | AR-DOM 1
1097934 | Nivel 2 | 1.72681 | 0.609488 | 0.00285724 | 0.115498 | AR-DOM 1
1097938 | Nivel 2 | 1.91437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1097940 | Nivel 2 | 1.74076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1097944 | Nivel 2 | 2.8332 | 0.348871 | 0.00285724 | 0.0661114 | AR-DOM 1
1097949 | Nivel 2 | 2.57664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1097952 | Nivel 2 | 2.83626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1097959 | Nivel 2 | 2.22177 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1097962 | Nivel 2 | 2.49949 | 0.00965806 | 0.00285724 | 0.00183021 | AR-DOM 1; VENT 6
1097968 | Nivel 2 | 2.17195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1097970 | Nivel 2 | 2.17362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1097978 | Nivel 2 | 2.25598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1097980 | Nivel 2 | 2.82276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1097986 | Nivel 2 | 1.8399 | 0.0273238 | 0.00285724 | 0.00517789 | AR-DOM 1
1097989 | Nivel 2 | 1.95168 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1097992 | Nivel 2 | 1.84021 | 0.161068 | 0.00285724 | 0.0305226 | AR-DOM 1
1098002 | Nivel 2 | 2.18109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1098004 | Nivel 1 | 2.44432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1098008 | Nivel 1 | 2.92234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1098014 | Nivel 2 | 2.2621 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1098018 | Nivel 2 | 2.33653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1098024 | Nivel 2 | 3.12611 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1098026 | Nivel 2 | 3.06644 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1098036 | Nivel 2 | 4.71977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1098038 | Nivel 2 | 4.71914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1098042 | Nivel 2 | 4.71484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1098046 | Nivel 3 | 4.71416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1098050 | Nivel 3 | 4.7122 | 0.361245 | 0.00285724 | 0.0684562 | AR-DOM 1
1098054 | Nivel 3 | 4.53095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1098056 | Nivel 3 | 4.53019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1098062 | Nivel 3 | 4.52304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1098068 | Nivel 3 | 4.5201 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1098070 | Nivel 3 | 4.52195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1098073 | Nivel 3 | 4.52231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1098076 | Nivel 3 | 4.52366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1098078 | Nivel 3 | 4.52924 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1098081 | Nivel 3 | 4.52924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1098084 | Nivel 3 | 4.52948 | 0.0483453 | 0.00285724 | 0.00916148 | AR-DOM 1
1098086 | Nivel 3 | 4.52941 | 0.200589 | 0.0102593 | 0.0720282 | AR-DOM 1
1098090 | Nivel 3 | 4.37722 | 0.186142 | 0.0102593 | 0.0668407 | AR-DOM 1
1098094 | Nivel 3 | 5.29498 | 0.916438 | 0.0102593 | 0.329078 | AR-DOM 1
1098100 | Nivel 3 | 4.70534 | 1.28051 | 0.00285724 | 0.242658 | AR-DOM 1
1098108 | Nivel 3 | 4.07681 | 0.609488 | 0.00285724 | 0.115498 | AR-DOM 1
1098112 | Nivel 3 | 4.26437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1098114 | Nivel 3 | 4.09076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1098118 | Nivel 3 | 5.1832 | 0.348823 | 0.00285724 | 0.0661023 | AR-DOM 1
1098123 | Nivel 3 | 4.92664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1098126 | Nivel 3 | 5.18626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1098133 | Nivel 3 | 4.57177 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1098136 | Nivel 3 | 4.84949 | 0.00972585 | 0.00285724 | 0.00184306 | AR-DOM 1; VENT 6
1098142 | Nivel 3 | 4.52195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1098144 | Nivel 3 | 4.52362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1098152 | Nivel 3 | 4.60598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1098154 | Nivel 3 | 5.17276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1098160 | Nivel 3 | 4.1899 | 0.0273266 | 0.00285724 | 0.00517841 | AR-DOM 1
1098163 | Nivel 3 | 4.30168 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1098166 | Nivel 3 | 4.19021 | 0.161114 | 0.00285724 | 0.0305313 | AR-DOM 1
1098176 | Nivel 3 | 4.53109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1098178 | Nivel 2 | 4.79432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1098182 | Nivel 2 | 5.27234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1098188 | Nivel 3 | 4.6121 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1098192 | Nivel 3 | 4.68653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1098198 | Nivel 3 | 5.47611 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1098200 | Nivel 3 | 5.41644 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1098206 | Nivel 3 | 7.06977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1098208 | Nivel 3 | 7.06914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1098212 | Nivel 3 | 7.06484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
1098216 | Nivel 4 | 7.06416 | 0.0977554 | 0.00285724 | 0.0185247 | AR-DOM 1
1098220 | Nivel 4 | 7.0622 | 0.361245 | 0.00285724 | 0.0684562 | AR-DOM 1
1098224 | Nivel 4 | 6.88095 | 0.29593 | 0.00285724 | 0.056079 | AR-DOM 1
1098226 | Nivel 4 | 6.88019 | 0.114453 | 0.00285724 | 0.0216889 | AR-DOM 1
1098232 | Nivel 4 | 6.87304 | 0.0871264 | 0.00285724 | 0.0165105 | AR-DOM 1
1098238 | Nivel 4 | 6.8701 | 0.267727 | 0.00285724 | 0.0507345 | AR-DOM 1
1098240 | Nivel 4 | 6.87195 | 0.0673013 | 0.00285724 | 0.0127536 | AR-DOM 1
1098243 | Nivel 4 | 6.87231 | 0.107754 | 0.00285724 | 0.0204194 | AR-DOM 1
1098246 | Nivel 4 | 6.87366 | 0.94125 | 0.00285724 | 0.178368 | AR-DOM 1
1098248 | Nivel 4 | 6.87924 | 0.0386365 | 0.00285724 | 0.00732166 | AR-DOM 1
1098251 | Nivel 4 | 6.87924 | 0.151652 | 0.00285724 | 0.0287382 | AR-DOM 1
1098254 | Nivel 4 | 6.87948 | 0.0483453 | 0.00285724 | 0.00916148 | AR-DOM 1
1098256 | Nivel 4 | 6.87941 | 0.200589 | 0.0102593 | 0.0720282 | AR-DOM 1
1098260 | Nivel 4 | 6.72722 | 0.186142 | 0.0102593 | 0.0668407 | AR-DOM 1
1098268 | Nivel 4 | 7.05534 | 1.28051 | 0.00285724 | 0.242658 | AR-DOM 1
1098276 | Nivel 4 | 6.42681 | 0.609488 | 0.00285724 | 0.115498 | AR-DOM 1
1098280 | Nivel 4 | 6.61437 | 0.236684 | 0.00285724 | 0.0448519 | AR-DOM 1
1098282 | Nivel 4 | 6.44076 | 0.0200426 | 0.0102593 | 0.00719697 | AR-DOM 1
1098286 | Nivel 4 | 7.5332 | 0.348823 | 0.00285724 | 0.0661023 | AR-DOM 1
1098291 | Nivel 4 | 7.27664 | 0.177467 | 0.0102593 | 0.0637257 | AR-DOM 1
1098294 | Nivel 4 | 7.53626 | 0.114354 | 0.00285724 | 0.0216702 | AR-DOM 1
1098301 | Nivel 4 | 6.92177 | 0.122851 | 0.0102593 | 0.0441138 | AR-DOM 1
1098304 | Nivel 4 | 7.19949 | 0.00972585 | 0.00285724 | 0.00184306 | AR-DOM 1; VENT 6
1098310 | Nivel 4 | 6.87195 | 0.0803484 | 0.00285724 | 0.0152261 | AR-DOM 1
1098312 | Nivel 4 | 6.87362 | 0.206381 | 0.00285724 | 0.0391094 | AR-DOM 1
1098320 | Nivel 4 | 6.95598 | 0.548202 | 0.00285724 | 0.103885 | AR-DOM 1
1098322 | Nivel 4 | 7.52276 | 0.0386745 | 0.00285724 | 0.00732885 | AR-DOM 1
1098328 | Nivel 4 | 6.5399 | 0.0273266 | 0.00285724 | 0.00517841 | AR-DOM 1
1098331 | Nivel 4 | 6.65168 | 0.0154628 | 0.0102593 | 0.00555244 | AR-DOM 1
1098334 | Nivel 4 | 6.54021 | 0.161114 | 0.00285724 | 0.0305313 | AR-DOM 1
1098344 | Nivel 4 | 6.88109 | 0.0618323 | 0.00285724 | 0.0117173 | AR-DOM 1
1098346 | Nivel 3 | 7.14432 | 0.459633 | 0.00285724 | 0.0871009 | AR-DOM 1
1098350 | Nivel 3 | 7.62234 | 0.0389519 | 0.00285724 | 0.00738143 | AR-DOM 1
1098356 | Nivel 4 | 6.9621 | 0.182909 | 0.00285724 | 0.0346614 | AR-DOM 1
1098360 | Nivel 4 | 7.03653 | 0.0434685 | 0.00285724 | 0.00823731 | AR-DOM 1
1098366 | Nivel 4 | 7.82611 | 0.01 | 0.00285724 | 0.00189501 | AR-DOM 1
1098368 | Nivel 4 | 7.76644 | 0.00964466 | 0.00285724 | 0.00182767 | AR-DOM 1
1098374 | Nivel 4 | 9.41977 | 0.204864 | 0.00285724 | 0.0388219 | AR-DOM 1
1098376 | Nivel 4 | 9.41914 | 0.0883322 | 0.00285724 | 0.016739 | AR-DOM 1
1098380 | Nivel 4 | 9.41484 | 0.822078 | 0.00285724 | 0.155785 | AR-DOM 1
