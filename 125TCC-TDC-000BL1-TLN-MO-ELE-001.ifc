Properties of the parts of a building model (IFC4), part 18 of 18

# IfcDistributionPort (15965)
Name | PredefinedType | SystemType
Port_3035518_2 | CABLECARRIER | CONVEYING
Port_3035517_1 | CABLECARRIER | CONVEYING
Port_3035521_1 | CABLECARRIER | CONVEYING
Port_3035520_0 | CABLECARRIER | CONVEYING
Port_3035521_2 | CABLECARRIER | CONVEYING
Port_3035523_6 | CABLE | ELECTRICAL
Port_3035524_0 | CABLECARRIER | CONVEYING
Port_3035525_2 | CABLECARRIER | CONVEYING
Port_3035531_1 | CABLECARRIER | CONVEYING
Port_3035533_1 | CABLECARRIER | CONVEYING
Port_3035532_0 | CABLECARRIER | CONVEYING
Port_3035533_2 | CABLECARRIER | CONVEYING
Port_3035532_1 | CABLECARRIER | CONVEYING
Port_3035539_1 | CABLECARRIER | CONVEYING
Port_3035535_1 | CABLECARRIER | CONVEYING
Port_3035536_2 | CABLECARRIER | CONVEYING
Port_3035538_1 | CABLECARRIER | CONVEYING
Port_3035539_2 | CABLECARRIER | CONVEYING

# IfcDistributionSystem (50)
PredefinedType: ELECTRICAL
Name | Reference
13 x 1 | 1
13 x 2 | 2
12 x 3 | 3
12 x 4 | 4

# IfcElementAssembly: Communication Devices Assembly:COM-APTO 101, Communication Devices Assembly:COM-APTO 101:1540671
In: Level 2
PredefinedType: USERDEFINED; Classification: D6030 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: COM-APTO 101; sets with these values: 2

# IfcElementAssembly: Communication Devices Assembly:COM-APTO 103, Communication Devices Assembly:COM-APTO 103:1526642
In: Level 2
PredefinedType: USERDEFINED; Classification: D6030 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: COM-APTO 103; sets with these values: 2

# IfcElementAssembly: Communication Devices Assembly:COM-APTO 104, Communication Devices Assembly:COM-APTO 104:1535947
In: Level 2
PredefinedType: USERDEFINED; Classification: D6030 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: COM-APTO 104; sets with these values: 2

# IfcElementAssembly: Communication Devices Assembly:COM-APTO 207, Communication Devices Assembly:COM-APTO 207:1540355
In: Level 2
PredefinedType: USERDEFINED; Classification: D6030 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: COM-APTO 207; sets with these values: 2

# IfcElementAssembly: Communication Devices Assembly:COM-APTO 218, Communication Devices Assembly:COM-APTO 218:1590130
In: Level 6
PredefinedType: USERDEFINED; Classification: D6030 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: COM-APTO 218; sets with these values: 2

# IfcElementAssembly: Communication Devices Assembly:COM-APTO 219, Communication Devices Assembly:COM-APTO 219:1589316
In: Level 6
PredefinedType: USERDEFINED; Classification: D6030 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: COM-APTO 219; sets with these values: 2

# IfcElementAssembly: Communication Devices Assembly:COM-APTO 220, Communication Devices Assembly:COM-APTO 220:1590131
In: Level 6
PredefinedType: USERDEFINED; Classification: D6030 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: COM-APTO 220; sets with these values: 2

# IfcElementAssembly: Communication Devices Assembly:COM-APTO 221, Communication Devices Assembly:COM-APTO 221:1590106
In: Level 6
PredefinedType: USERDEFINED; Classification: D6030 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: COM-APTO 221; sets with these values: 2

# IfcElementAssembly: Communication Devices Assembly:COM-APTO 222 (4)
PredefinedType: USERDEFINED; Classification: D6030 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: COM-APTO 222; sets with these values: 2
Name (Communication Devices Assembly:COM-APTO 222:...) | In
1557253 | Nivel 1
3025848 | Nivel 2
3031817 | Level 4
3034408 | Level 5

# IfcElementAssembly: Communication Devices Assembly:COM-APTO 223, Communication Devices Assembly:COM-APTO 223:1557485
In: Nivel 1
PredefinedType: USERDEFINED; Classification: D6030 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: COM-APTO 223; sets with these values: 2

# IfcElementAssembly: Communication Devices Assembly:COM-APTO 224, Communication Devices Assembly:COM-APTO 224:1555312
In: Nivel 1
PredefinedType: USERDEFINED; Classification: D6030 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: COM-APTO 224; sets with these values: 2

# IfcElementAssembly: Communication Devices Assembly:COM-APTO 225, Communication Devices Assembly:COM-APTO 225:1557490
In: Nivel 1
PredefinedType: USERDEFINED; Classification: D6030 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: COM-APTO 225; sets with these values: 2

# IfcElementAssembly: Communication Devices Assembly:Vertical Comunicaciones, Communication Devices Assembly:Vertical Comunicaciones:1547783
In: Level 2
PredefinedType: USERDEFINED; Classification: D5020.30 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: Vertical Comunicaciones; sets with these values: 2

# IfcElementAssembly: Electrical Equipment Assembly:Vertical Acometidas, Electrical Equipment Assembly:Vertical Acometidas:1548591
In: Level 2
PredefinedType: USERDEFINED; Classification: D5020.10 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: Vertical Acometidas; sets with these values: 2

# IfcElementAssembly: Electrical Fixtures Assembly:ELE-APTO 101, Electrical Fixtures Assembly:ELE-APTO 101:1533368
In: Level 2
PredefinedType: USERDEFINED; Classification: D5030.50 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: ELE-APTO 101; sets with these values: 2

# IfcElementAssembly: Electrical Fixtures Assembly:ELE-APTO 102, Electrical Fixtures Assembly:ELE-APTO 102:1541979
In: Level 2
PredefinedType: USERDEFINED; Classification: D5030.50 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: ELE-APTO 102; sets with these values: 2

# IfcElementAssembly: Electrical Fixtures Assembly:ELE-APTO 103, Electrical Fixtures Assembly:ELE-APTO 103:1526572
In: Level 2
PredefinedType: USERDEFINED; Classification: D5030.50 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: ELE-APTO 103; sets with these values: 2

# IfcElementAssembly: Electrical Fixtures Assembly:ELE-APTO 104, Electrical Fixtures Assembly:ELE-APTO 104:1527879
In: Level 2
PredefinedType: USERDEFINED; Classification: D5030.50 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: ELE-APTO 104; sets with these values: 2

# IfcElementAssembly: Electrical Fixtures Assembly:ELE-APTO 201, Electrical Fixtures Assembly:ELE-APTO 201:1556133
In: Nivel 1
PredefinedType: USERDEFINED; Classification: D5030.50 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: ELE-APTO 201; sets with these values: 2

# IfcElementAssembly: Electrical Fixtures Assembly:ELE-APTO 202 (4)
PredefinedType: USERDEFINED; Classification: D5030.50 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: ELE-APTO 202; sets with these values: 2
Name (Electrical Fixtures Assembly:ELE-APTO 202:...) | In
1556139 | Nivel 1
3025632 | Nivel 2
3031601 | Level 4
3034192 | Level 5

# IfcElementAssembly: Electrical Fixtures Assembly:ELE-APTO 203 (4)
PredefinedType: USERDEFINED; Classification: D5030.50 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: ELE-APTO 203; sets with these values: 2
Name (Electrical Fixtures Assembly:ELE-APTO 203:...) | In
1554702 | Nivel 1
3025287 | Nivel 2
3031261 | Level 4
3033852 | Level 5

# IfcElementAssembly: Electrical Fixtures Assembly:ELE-APTO 204 (4)
PredefinedType: USERDEFINED; Classification: D5030.50 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: ELE-APTO 204; sets with these values: 2
Name (Electrical Fixtures Assembly:ELE-APTO 204:...) | In
1556443 | Nivel 1
3025786 | Nivel 2
3031755 | Level 4
3034346 | Level 5

# IfcElementAssembly: Electrical Fixtures Assembly:ELE-APTO 205 (3)
PredefinedType: USERDEFINED; Classification: D5030.50 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: ELE-APTO 205; sets with these values: 2
Name (Electrical Fixtures Assembly:ELE-APTO 205:...) | In
3025631 | Nivel 2
3031600 | Level 4
3034191 | Level 5

# IfcElementAssembly: Electrical Fixtures Assembly:ELE-APTO 601, Electrical Fixtures Assembly:ELE-APTO 601:1618631
In: Level 6
PredefinedType: USERDEFINED; Classification: D5030.50 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: ELE-APTO 601; sets with these values: 2

# IfcElementAssembly: Electrical Fixtures Assembly:ELE-APTO 602, Electrical Fixtures Assembly:ELE-APTO 602:1618633
In: Level 6
PredefinedType: USERDEFINED; Classification: D5030.50 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: ELE-APTO 602; sets with these values: 2

# IfcElementAssembly: Electrical Fixtures Assembly:ELE-APTO 603, Electrical Fixtures Assembly:ELE-APTO 603:1618635
In: Level 6
PredefinedType: USERDEFINED; Classification: D5030.50 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: ELE-APTO 603; sets with these values: 2

# IfcElementAssembly: Electrical Fixtures Assembly:ELE-APTO 604, Electrical Fixtures Assembly:ELE-APTO 604:1618637
In: Level 6
PredefinedType: USERDEFINED; Classification: D5030.50 Uniformat (Uniformat)
Pset_ElementAssemblyCommon - Reference: ELE-APTO 604; sets with these values: 2

# IfcLightFixture: Aplique:60W - 120V (136)
Type - Material: Default Light Source, <Unnamed>
Classification: D5040.50 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: 60W - 120V; sets with these values: 2
Name (Aplique:60W - 120V:...) | In | Group
1489150 | Level 2 | 4
1489154 | Level 2 | 4
1489155 | Level 2 | 3
1489160 | Level 2 | 3
1489395 | Level 2 | 3
1518274 | Level 2 | 3
1527550 | Level 2 | 4
1527554 | Level 2 | 4
1527560 | Level 2 | 3
1527661 | Level 2 | 3
1527813 | Level 2 | 3
1533076 | Level 2 | 4
1533080 | Level 2 | 4
1533081 | Level 2 | 3
1533086 | Level 2 | 3
1533183 | Level 2 | 3
1533304 | Level 2 | 3
1533881 | Level 2 | 3
1541700 | Level 2 | 4
1541704 | Level 2 | 4
1541705 | Level 2 | 3
1541710 | Level 2 | 3
1541804 | Level 2 | 3
1541917 | Level 2 | 3
1554306 | Nivel 1 | 4
1554310 | Nivel 1 | 4
1554311 | Nivel 1 | 3
1554316 | Nivel 1 | 3
1554934 | Nivel 1 | 4
1554938 | Nivel 1 | 4
1554939 | Nivel 1 | 3
1554944 | Nivel 1 | 3
1555038 | Nivel 1 | 3
1555424 | Nivel 1 | 4
1555428 | Nivel 1 | 4
1555429 | Nivel 1 | 3
1555434 | Nivel 1 | 3
1555526 | Nivel 1 | 3
1556150 | Nivel 1 | 4
1556154 | Nivel 1 | 4
1556155 | Nivel 1 | 3
1556160 | Nivel 1 | 3
1556260 | Nivel 1 | 3
1588574 | Level 6 | 4
1588578 | Level 6 | 4
1588579 | Level 6 | 3
1588584 | Level 6 | 3
1588695 | Level 6 | 3
1588986 | Level 6 | 4
1588990 | Level 6 | 4
1588991 | Level 6 | 3
1588996 | Level 6 | 3
1589086 | Level 6 | 3
1589416 | Level 6 | 4
1589420 | Level 6 | 4
1589421 | Level 6 | 3
1589426 | Level 6 | 3
1589512 | Level 6 | 3
1589760 | Level 6 | 4
1589764 | Level 6 | 4
1589765 | Level 6 | 3
1589770 | Level 6 | 3
1589858 | Level 6 | 3
1591454 | Level 6 | 3
1592007 | Level 6 | 3
1616525 | Level 6 | 3
1617261 | Level 6 | 3
1617267 | Level 6 | 3
1617286 | Level 6 | 3
1617291 | Level 6 | 3
1617309 | Level 6 | 3
1617314 | Level 6 | 3
1617332 | Level 6 | 3
1617341 | Level 6 | 3
1617350 | Level 6 | 3
2210108 | Nivel 1 | 3
3025128 | Nivel 2
3025132 | Nivel 2
3025133 | Nivel 2
3025138 | Nivel 2
3025296 | Nivel 2
3025300 | Nivel 2
3025301 | Nivel 2
3025306 | Nivel 2
3025371 | Nivel 2
3025463 | Nivel 2
3025467 | Nivel 2
3025468 | Nivel 2
3025473 | Nivel 2
3025539 | Nivel 2
3025640 | Nivel 2
3025644 | Nivel 2
3025645 | Nivel 2
3025650 | Nivel 2
3025714 | Nivel 2
3026398 | Nivel 2
3031102 | Level 4
3031106 | Level 4
3031107 | Level 4
3031112 | Level 4
3031270 | Level 4
3031274 | Level 4
3031275 | Level 4
3031280 | Level 4
3031345 | Level 4
3031435 | Level 4
3031439 | Level 4
3031440 | Level 4
3031445 | Level 4
3031511 | Level 4
3031609 | Level 4
3031613 | Level 4
3031614 | Level 4
3031619 | Level 4
3031683 | Level 4
3032313 | Level 4
3033693 | Level 5
3033697 | Level 5
3033698 | Level 5
3033703 | Level 5
3033861 | Level 5
3033865 | Level 5
3033866 | Level 5
3033871 | Level 5
3033936 | Level 5
3034026 | Level 5
3034030 | Level 5
3034031 | Level 5
3034036 | Level 5
3034102 | Level 5
3034200 | Level 5
3034204 | Level 5
3034205 | Level 5
3034210 | Level 5
3034274 | Level 5
3034904 | Level 5

# IfcLightFixture: Bala Led Techo:18W - 120V (48)
Type - Material: <Unnamed> (2), Steel, Paint Finish, Dark Gray, Matte
Classification: D5040.50 Uniformat (Uniformat); Material: <Unnamed>, Steel, Paint Finish, Dark Gray, Matte
Pset_EnvironmentalImpactIndicators - Reference: 18W - 120V; sets with these values: 2
Name (Bala Led Techo:18W - 120V:...) | In
1489164 | Level 2 | Group: 3
1489454 | Level 2 | Group: 3
1527562 | Level 2 | Group: 3
1527679 | Level 2 | Group: 3
1533088 | Level 2 | Group: 3
1533201 | Level 2 | Group: 3
1541712 | Level 2 | Group: 3
1541821 | Level 2 | Group: 3
1554320 | Nivel 1 | Group: 3
1554450 | Nivel 1 | Group: 3
1554946 | Nivel 1 | Group: 3
1555055 | Nivel 1 | Group: 3
1555436 | Nivel 1 | Group: 3
1555543 | Nivel 1 | Group: 3
1556162 | Nivel 1 | Group: 3
1556278 | Nivel 1 | Group: 3
1588588 | Level 6 | Group: 3
1588713 | Level 6 | Group: 3
1588998 | Level 6 | Group: 3
1589103 | Level 6 | Group: 3
1589428 | Level 6 | Group: 3
1589527 | Level 6 | Group: 3
1589772 | Level 6 | Group: 3
1711040 | Level 6 | Group: 3
3025140 | Nivel 2
3025214 | Nivel 2
3025308 | Nivel 2
3025380 | Nivel 2
3025475 | Nivel 2
3025548 | Nivel 2
3025652 | Nivel 2
3025724 | Nivel 2
3031114 | Level 4
3031188 | Level 4
3031282 | Level 4
3031354 | Level 4
3031447 | Level 4
3031520 | Level 4
3031621 | Level 4
3031693 | Level 4
3033705 | Level 5
3033779 | Level 5
3033873 | Level 5
3033945 | Level 5
3034038 | Level 5
3034111 | Level 5
3034212 | Level 5
3034284 | Level 5

# IfcLightFixture: EXIT S LED 5:EXIT S LED 5 (11)
Type - Material: Polycarbonate-Philips-Clear, Plastic-Philips-White
Type - Pset_ElectricalDeviceCommon - PowerFactor: 0.9; NumberOfPoles: 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Philips Chloride
Pset_EnvironmentalImpactIndicators - Reference: EXIT S LED 5; sets with these values: 2
Group: 2
Name (EXIT S LED 5:EXIT S LED 5:...) | In
2693355 | Level 2
2693365 | Level 3
2693375 | Level 4
2693385 | Level 5
2693395 | Level 6
2693397 | Level 7
2693400 | Level 3
2693405 | Level 4
2693410 | Level 5
2693415 | Level 6
2693420 | Level 7

# IfcLightFixture: Roseta:60W - 120V (60)
Type - Material: <Unnamed>
Classification: D5040.50 Uniformat (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: 60W - 120V; sets with these values: 2
Name (Roseta:60W - 120V:...) | In
1489262 | Level 2 | Group: 3
1489263 | Level 2 | Group: 3
1489269 | Level 2 | Group: 3
1527609 | Level 2 | Group: 3
1527610 | Level 2 | Group: 3
1527614 | Level 2 | Group: 3
1533134 | Level 2 | Group: 3
1533135 | Level 2 | Group: 3
1533139 | Level 2 | Group: 3
1541757 | Level 2 | Group: 3
1541758 | Level 2 | Group: 3
1541762 | Level 2 | Group: 3
1554367 | Nivel 1 | Group: 3
1554368 | Nivel 1 | Group: 3
1554372 | Nivel 1 | Group: 3
1554991 | Nivel 1 | Group: 3
1554992 | Nivel 1 | Group: 3
1554996 | Nivel 1 | Group: 3
1555481 | Nivel 1 | Group: 3
1555482 | Nivel 1 | Group: 3
1555486 | Nivel 1 | Group: 3
1556209 | Nivel 1 | Group: 3
1556210 | Nivel 1 | Group: 3
1556214 | Nivel 1 | Group: 3
3025178 | Nivel 2
3025179 | Nivel 2
3025183 | Nivel 2
3025343 | Nivel 2
3025344 | Nivel 2
3025348 | Nivel 2
3025510 | Nivel 2
3025511 | Nivel 2
3025515 | Nivel 2
3025685 | Nivel 2
3025686 | Nivel 2
3025690 | Nivel 2
3031152 | Level 4
3031153 | Level 4
3031157 | Level 4
3031317 | Level 4
3031318 | Level 4
3031322 | Level 4
3031482 | Level 4
3031483 | Level 4
3031487 | Level 4
3031654 | Level 4
3031655 | Level 4
3031659 | Level 4
3033743 | Level 5
3033744 | Level 5
3033748 | Level 5
3033908 | Level 5
3033909 | Level 5
3033913 | Level 5
3034073 | Level 5
3034074 | Level 5
3034078 | Level 5
3034245 | Level 5
3034246 | Level 5
3034250 | Level 5

# IfcLightFixture: S D22 LED18:S D22 LED 18 (24)
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Philips
Pset_EnvironmentalImpactIndicators - Reference: S D22 LED 18; sets with these values: 2
Group: 1
Name (S D22 LED18:S D22 LED 18:...) | In
2693350 | Level 2
2693352 | Level 2
2693353 | Level 2
2693354 | Level 2
2693356 | Level 3
2693366 | Level 4
2693376 | Level 5
2693386 | Level 6
2693396 | Level 7
2693399 | Level 3
2693402 | Level 3
2693403 | Level 3
2693404 | Level 4
2693407 | Level 4
2693408 | Level 4
2693409 | Level 5
2693412 | Level 5
2693413 | Level 5
2693414 | Level 6
2693417 | Level 6
2693418 | Level 6
2693419 | Level 7
2693422 | Level 7
2693424 | Level 7
