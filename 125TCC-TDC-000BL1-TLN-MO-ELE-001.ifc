Properties of the parts of a building model (IFC4), part 2 of 18

# IfcCableCarrierFitting: Codo sin Restriccion:Standard (2698)
Name (Codo sin Restriccion:Standard:...) | In
2669976 | Level 2
2670017 | Level 2
2670336 | Level 2
2670369 | Level 2
2672868 | Level 6
2672871 | Level 6
2673081 | Level 6
2673083 | Level 6
2675355 | Level 6
2675357 | Level 6
2675533 | Level 6
2675536 | Level 6
2675650 | Level 6
2675652 | Level 6
2675689 | Level 6
2675691 | Level 6
2677355 | Level 6
2677358 | Level 6
2677510 | Level 6
2677512 | Level 6
2677578 | Level 6
2677580 | Level 6
2680891 | Level 2
2680893 | Level 2
2681806 | Nivel 2
2682266 | Level 2
2682487 | Nivel 3
2682537 | Nivel 4
2682587 | Nivel 5
2719569 | Level 2
2745844 | Level 6
2745848 | Level 6
2745868 | Level 6
2780852 | Level 2
2781336 | Level 2
2784422 | Level 2
2808568 | Level 2
2834621 | Level 2
2845993 | Level 2
2847594 | Level 2
2853769 | Nivel 1
2863916 | Nivel 1
2868680 | Nivel 1
2875011 | Nivel 1
2875507 | Nivel 1
2880086 | Level 6
2887166 | Level 6
2890193 | Level 6
2893490 | Level 6
2909482 | Level 2
2922936 | Level 2
2955224 | Level 2
2957945 | Level 2
2959836 | Level 6
3025187 | Nivel 2
3025231 | Nivel 2
3025251 | Nivel 2
3025254 | Nivel 2
3025259 | Nivel 2
3025261 | Nivel 2
3025265 | Nivel 2
3025268 | Nivel 2
3025272 | Nivel 2
3025275 | Nivel 2
3025278 | Nivel 2
3025280 | Nivel 2
3025283 | Nivel 2
3025285 | Nivel 2
3025352 | Nivel 2
3025362 | Nivel 2
3025401 | Nivel 2
3025415 | Nivel 2
3025418 | Nivel 2
3025421 | Nivel 2
3025425 | Nivel 2
3025428 | Nivel 2
3025432 | Nivel 2
3025435 | Nivel 2
3025438 | Nivel 2
3025440 | Nivel 2
3025442 | Nivel 2
3025447 | Nivel 2
3025449 | Nivel 2
3025519 | Nivel 2
3025564 | Nivel 2
3025567 | Nivel 2
3025571 | Nivel 2
3025583 | Nivel 2
3025586 | Nivel 2
3025591 | Nivel 2
3025593 | Nivel 2
3025597 | Nivel 2
3025600 | Nivel 2
3025604 | Nivel 2
3025607 | Nivel 2
3025610 | Nivel 2
3025612 | Nivel 2
3025615 | Nivel 2
3025619 | Nivel 2
3025694 | Nivel 2
3025704 | Nivel 2
3025742 | Nivel 2
3025752 | Nivel 2
3025755 | Nivel 2
3025760 | Nivel 2
3025762 | Nivel 2
3025766 | Nivel 2
3025769 | Nivel 2
3025773 | Nivel 2
3025776 | Nivel 2
3025779 | Nivel 2
3025781 | Nivel 2
3025784 | Nivel 2
3025808 | Nivel 2
3025811 | Nivel 2
3025816 | Nivel 2
3025818 | Nivel 2
3025820 | Nivel 2
3025824 | Nivel 2
3025827 | Nivel 2
3025830 | Nivel 2
3025834 | Nivel 2
3025837 | Nivel 2
3025842 | Nivel 2
3025846 | Nivel 2
3025866 | Nivel 2
3025869 | Nivel 2
3025872 | Nivel 2
3025874 | Nivel 2
3025883 | Nivel 2
3025886 | Nivel 2
3025889 | Nivel 2
3025891 | Nivel 2
3025900 | Nivel 2
3025903 | Nivel 2
3025906 | Nivel 2
3025908 | Nivel 2
3025917 | Nivel 2
3025920 | Nivel 2
3025923 | Nivel 2
3025925 | Nivel 2
3025931 | Nivel 2
3025934 | Nivel 2
3025937 | Nivel 2
3025940 | Nivel 2
3025955 | Nivel 2
3025957 | Nivel 2
3025959 | Nivel 2
3025961 | Nivel 2
3025964 | Nivel 2
3025966 | Nivel 2
3025968 | Nivel 2
3025971 | Nivel 2
3025975 | Nivel 2
3025977 | Nivel 2
3025979 | Nivel 2
3025982 | Nivel 2
3025988 | Nivel 2
3025990 | Nivel 2
3025993 | Nivel 2
3025998 | Nivel 2
3026000 | Nivel 2
3026007 | Nivel 2
3026011 | Nivel 2
3026014 | Nivel 2
3026018 | Nivel 2
3026027 | Nivel 2
3026033 | Nivel 2
3026035 | Nivel 2
3026039 | Nivel 2
3026042 | Nivel 2
3026045 | Nivel 2
3026047 | Nivel 2
3026049 | Nivel 2
3026051 | Nivel 2
3026056 | Nivel 2
3026070 | Nivel 2
3026073 | Nivel 2
3026076 | Nivel 2
3026079 | Nivel 2
3026083 | Nivel 2
3026085 | Nivel 2
3026087 | Nivel 2
3026089 | Nivel 2
3026094 | Nivel 2
3026096 | Nivel 2
3026099 | Nivel 2
3026104 | Nivel 2
3026106 | Nivel 2
3026108 | Nivel 2
3026111 | Nivel 2
3026121 | Nivel 2
3026127 | Nivel 2
3026130 | Nivel 2
3026132 | Nivel 2
3026139 | Nivel 2
3026142 | Nivel 2
3026144 | Nivel 2
3026148 | Nivel 2
3026150 | Nivel 2
3026154 | Nivel 2
3026156 | Nivel 2
3026169 | Nivel 2
3026172 | Nivel 2
3026175 | Nivel 2
3026177 | Nivel 2
3026179 | Nivel 2
3026186 | Nivel 2
3026192 | Nivel 2
3026194 | Nivel 2
3026198 | Nivel 2
3026200 | Nivel 2
3026203 | Nivel 2
3026206 | Nivel 2
3026229 | Nivel 2
3026235 | Nivel 2
3026237 | Nivel 2
3026239 | Nivel 2
3026244 | Nivel 2
3026246 | Nivel 2
3026249 | Nivel 2
3026253 | Nivel 2
3026255 | Nivel 2
3026258 | Nivel 2
3026262 | Nivel 2
3026273 | Nivel 2
3026276 | Nivel 2
3026278 | Nivel 2
3026285 | Nivel 2
3026291 | Nivel 2
3026293 | Nivel 2
3026295 | Nivel 2
3026299 | Nivel 2
3026301 | Nivel 2
3026303 | Nivel 2
3026313 | Nivel 2
3026316 | Nivel 2
3026319 | Nivel 2
3026321 | Nivel 2
3026323 | Nivel 2
3026325 | Nivel 2
3026327 | Nivel 2
3026331 | Nivel 2
3026334 | Nivel 2
3026337 | Nivel 2
3026339 | Nivel 2
3026341 | Nivel 2
3026355 | Nivel 2
3026359 | Nivel 2
3026363 | Nivel 2
3026365 | Nivel 2
3026367 | Nivel 2
3026373 | Nivel 2
3026376 | Nivel 2
3026378 | Nivel 2
3026380 | Nivel 2
3026383 | Nivel 2
3026385 | Nivel 2
3026391 | Nivel 2
3026393 | Nivel 2
3026399 | Nivel 2
3026404 | Nivel 2
3026407 | Nivel 2
3026409 | Nivel 2
3026415 | Nivel 2
3026417 | Nivel 2
3026425 | Nivel 2
3026429 | Nivel 2
3026431 | Nivel 2
3026433 | Nivel 2
3026436 | Nivel 2
3026446 | Nivel 2
3026449 | Nivel 2
3026452 | Nivel 2
3026454 | Nivel 2
3026456 | Nivel 2
3026458 | Nivel 2
3026463 | Nivel 2
3026465 | Nivel 2
3026468 | Nivel 2
3026470 | Nivel 2
3026472 | Nivel 2
3026474 | Nivel 2
3026483 | Nivel 2
3026504 | Nivel 2
3026507 | Nivel 2
3026510 | Nivel 2
3026512 | Nivel 2
3026517 | Nivel 2
3026520 | Nivel 2
3026522 | Nivel 2
3026524 | Nivel 2
3026531 | Nivel 2
3026533 | Nivel 2
3026535 | Nivel 2
3026537 | Nivel 2
3026542 | Nivel 2
3026544 | Nivel 2
3026547 | Nivel 2
3026549 | Nivel 2
3026551 | Nivel 2
3026553 | Nivel 2
3026555 | Nivel 2
3026559 | Nivel 2
3026561 | Nivel 2
3026563 | Nivel 2
3026565 | Nivel 2
3026569 | Nivel 2
3026579 | Nivel 2
3026584 | Nivel 2
3026589 | Nivel 2
3026595 | Nivel 2
3026600 | Nivel 2
3026605 | Nivel 2
3026611 | Nivel 2
3026617 | Nivel 2
3026622 | Nivel 2
3026624 | Nivel 2
3026626 | Nivel 2
3026628 | Nivel 2
3026633 | Nivel 2
3026635 | Nivel 2
3026637 | Nivel 2
3026639 | Nivel 2
3026644 | Nivel 2
3026646 | Nivel 2
3026648 | Nivel 2
3026653 | Nivel 2
3026655 | Nivel 2
3026657 | Nivel 2
3026662 | Nivel 2
3026664 | Nivel 2
3026666 | Nivel 2
3026673 | Nivel 2
3026676 | Nivel 2
3026679 | Nivel 2
3026683 | Nivel 2
3026685 | Nivel 2
3026690 | Nivel 2
3026693 | Nivel 2
3026696 | Nivel 2
3026698 | Nivel 2
3026700 | Nivel 2
3026707 | Nivel 2
3026710 | Nivel 2
3026713 | Nivel 2
3026717 | Nivel 2
3026719 | Nivel 2
3026724 | Nivel 2
3026727 | Nivel 2
3026730 | Nivel 2
3026732 | Nivel 2
3026738 | Nivel 2
3026743 | Nivel 2
3026746 | Nivel 2
3026749 | Nivel 2
3026753 | Nivel 2
3026760 | Nivel 2
3026763 | Nivel 2
3026766 | Nivel 2
3026770 | Nivel 2
3026776 | Nivel 2
3026779 | Nivel 2
3026784 | Nivel 2
3026787 | Nivel 2
3026789 | Nivel 2
3026795 | Nivel 2
3026800 | Nivel 2
3026803 | Nivel 2
3026806 | Nivel 2
3026810 | Nivel 2
3026815 | Nivel 2
3026818 | Nivel 2
3026821 | Nivel 2
3026823 | Nivel 2
3026825 | Nivel 2
3026832 | Nivel 2
3026835 | Nivel 2
3026838 | Nivel 2
3026840 | Nivel 2
3026842 | Nivel 2
3026849 | Nivel 2
3026852 | Nivel 2
3026855 | Nivel 2
3026857 | Nivel 2
3026859 | Nivel 2
3026865 | Nivel 2
3026868 | Nivel 2
3026873 | Nivel 2
3026876 | Nivel 2
3026879 | Nivel 2
3026881 | Nivel 2
3026883 | Nivel 2
3026887 | Nivel 2
3026894 | Nivel 2
3026897 | Nivel 2
3026903 | Nivel 2
3026906 | Nivel 2
3026909 | Nivel 2
3026913 | Nivel 2
3026917 | Nivel 2
3026921 | Nivel 2
3026928 | Nivel 2
3026931 | Nivel 2
3026937 | Nivel 2
3026940 | Nivel 2
3026943 | Nivel 2
3026947 | Nivel 2
3026951 | Nivel 2
3026953 | Nivel 2
3026960 | Nivel 2
3026963 | Nivel 2
3026969 | Nivel 2
3026972 | Nivel 2
3026975 | Nivel 2
3026979 | Nivel 2
3026983 | Nivel 2
3026987 | Nivel 2
3026994 | Nivel 2
3027008 | Nivel 2
3027017 | Nivel 2
3027031 | Nivel 2
3027035 | Nivel 2
3031161 | Level 4
3031205 | Level 4
3031225 | Level 4
3031228 | Level 4
3031233 | Level 4
3031235 | Level 4
3031239 | Level 4
3031242 | Level 4
3031246 | Level 4
3031249 | Level 4
3031252 | Level 4
3031254 | Level 4
3031257 | Level 4
3031259 | Level 4
3031326 | Level 4
3031336 | Level 4
3031375 | Level 4
3031389 | Level 4
3031392 | Level 4
3031395 | Level 4
3031399 | Level 4
3031402 | Level 4
3031406 | Level 4
3031409 | Level 4
3031412 | Level 4
3031414 | Level 4
3031416 | Level 4
3031421 | Level 4
3031423 | Level 4
3031491 | Level 4
3031536 | Level 4
3031539 | Level 4
3031543 | Level 4
3031555 | Level 4
3031558 | Level 4
3031563 | Level 4
3031565 | Level 4
3031569 | Level 4
3031572 | Level 4
3031576 | Level 4
3031579 | Level 4
3031582 | Level 4
3031584 | Level 4
3031587 | Level 4
3031591 | Level 4
3031663 | Level 4
3031673 | Level 4
3031711 | Level 4
3031721 | Level 4
3031724 | Level 4
3031729 | Level 4
3031731 | Level 4
3031735 | Level 4
3031738 | Level 4
3031742 | Level 4
3031745 | Level 4
3031748 | Level 4
3031750 | Level 4
3031753 | Level 4
3031777 | Level 4
3031780 | Level 4
3031785 | Level 4
3031787 | Level 4
3031789 | Level 4
3031793 | Level 4
3031796 | Level 4
3031799 | Level 4
3031803 | Level 4
3031806 | Level 4
3031811 | Level 4
3031815 | Level 4
3031835 | Level 4
3031838 | Level 4
3031841 | Level 4
3031843 | Level 4
3031852 | Level 4
3031855 | Level 4
3031858 | Level 4
3031860 | Level 4
3031869 | Level 4
3031872 | Level 4
3031875 | Level 4
3031877 | Level 4
3031886 | Level 4
3031889 | Level 4
3031892 | Level 4
3031894 | Level 4
3031900 | Level 4
3031903 | Level 4
3031906 | Level 4
3031909 | Level 4
3031920 | Level 4
3031922 | Level 4
3031924 | Level 4
3031926 | Level 4
3031929 | Level 4
3031931 | Level 4
3031933 | Level 4
3031936 | Level 4
3031940 | Level 4
3031942 | Level 4
3031944 | Level 4
3031947 | Level 4
3031953 | Level 4
3031955 | Level 4
3031958 | Level 4
3031963 | Level 4
3031965 | Level 4
3031970 | Level 4
3031974 | Level 4
3031976 | Level 4
3031980 | Level 4
3031987 | Level 4
3031993 | Level 4
3031995 | Level 4
3031999 | Level 4
3032002 | Level 4
3032005 | Level 4
3032007 | Level 4
3032009 | Level 4
3032011 | Level 4
3032014 | Level 4
3032023 | Level 4
3032026 | Level 4
3032029 | Level 4
3032032 | Level 4
3032035 | Level 4
3032037 | Level 4
3032039 | Level 4
3032041 | Level 4
3032045 | Level 4
3032047 | Level 4
3032049 | Level 4
3032054 | Level 4
3032056 | Level 4
3032058 | Level 4
3032061 | Level 4
3032069 | Level 4
3032075 | Level 4
3032078 | Level 4
3032080 | Level 4
3032085 | Level 4
3032087 | Level 4
3032089 | Level 4
3032093 | Level 4
3032095 | Level 4
3032099 | Level 4
3032101 | Level 4
3032114 | Level 4
3032117 | Level 4
3032120 | Level 4
3032122 | Level 4
3032124 | Level 4
3032130 | Level 4
3032136 | Level 4
3032138 | Level 4
3032142 | Level 4
3032144 | Level 4
3032146 | Level 4
3032148 | Level 4
3032164 | Level 4
3032170 | Level 4
3032172 | Level 4
3032174 | Level 4
3032178 | Level 4
3032180 | Level 4
3032183 | Level 4
3032187 | Level 4
3032189 | Level 4
3032192 | Level 4
3032196 | Level 4
3032205 | Level 4
3032208 | Level 4
3032210 | Level 4
3032215 | Level 4
3032221 | Level 4
3032223 | Level 4
3032225 | Level 4
3032228 | Level 4
3032230 | Level 4
3032232 | Level 4
3032240 | Level 4
3032243 | Level 4
3032246 | Level 4
3032248 | Level 4
3032250 | Level 4
3032252 | Level 4
3032254 | Level 4
3032258 | Level 4
3032260 | Level 4
3032263 | Level 4
3032265 | Level 4
3032267 | Level 4
3032275 | Level 4
3032279 | Level 4
3032283 | Level 4
3032285 | Level 4
3032287 | Level 4
3032292 | Level 4
3032295 | Level 4
3032297 | Level 4
3032299 | Level 4
3032302 | Level 4
3032304 | Level 4
3032309 | Level 4
3032311 | Level 4
3032314 | Level 4
3032318 | Level 4
3032321 | Level 4
3032323 | Level 4
3032329 | Level 4
3032331 | Level 4
3032337 | Level 4
3032341 | Level 4
3032343 | Level 4
3032345 | Level 4
3032348 | Level 4
3032358 | Level 4
3032361 | Level 4
3032364 | Level 4
3032366 | Level 4
3032368 | Level 4
3032370 | Level 4
3032374 | Level 4
3032376 | Level 4
3032379 | Level 4
3032381 | Level 4
3032383 | Level 4
3032385 | Level 4
3032391 | Level 4
3032410 | Level 4
3032413 | Level 4
3032416 | Level 4
3032418 | Level 4
3032423 | Level 4
3032426 | Level 4
3032428 | Level 4
3032430 | Level 4
3032437 | Level 4
3032439 | Level 4
3032441 | Level 4
3032443 | Level 4
3032448 | Level 4
3032450 | Level 4
3032453 | Level 4
3032455 | Level 4
3032457 | Level 4
3032459 | Level 4
3032461 | Level 4
3032465 | Level 4
3032467 | Level 4
3032469 | Level 4
3032471 | Level 4
3032475 | Level 4
3032485 | Level 4
3032490 | Level 4
3032495 | Level 4
3032501 | Level 4
3032506 | Level 4
3032511 | Level 4
3032517 | Level 4
3032523 | Level 4
3032528 | Level 4
3032530 | Level 4
3032532 | Level 4
3032534 | Level 4
3032539 | Level 4
3032541 | Level 4
3032543 | Level 4
3032545 | Level 4
3032550 | Level 4
3032552 | Level 4
3032554 | Level 4
3032559 | Level 4
3032561 | Level 4
3032563 | Level 4
3032568 | Level 4
3032570 | Level 4
3032572 | Level 4
3032579 | Level 4
3032582 | Level 4
3032585 | Level 4
3032589 | Level 4
3032591 | Level 4
3032596 | Level 4
3032599 | Level 4
3032602 | Level 4
3032604 | Level 4
3032606 | Level 4
3032613 | Level 4
3032616 | Level 4
3032619 | Level 4
3032623 | Level 4
3032625 | Level 4
3032630 | Level 4
3032633 | Level 4
3032636 | Level 4
3032638 | Level 4
3032644 | Level 4
3032649 | Level 4
3032652 | Level 4
3032655 | Level 4
3032659 | Level 4
3032666 | Level 4
3032669 | Level 4
3032672 | Level 4
3032676 | Level 4
3032682 | Level 4
3032685 | Level 4
3032690 | Level 4
3032693 | Level 4
3032695 | Level 4
3032701 | Level 4
3032706 | Level 4
3032709 | Level 4
3032712 | Level 4
3032716 | Level 4
3032721 | Level 4
3032724 | Level 4
3032727 | Level 4
3032729 | Level 4
3032731 | Level 4
3032738 | Level 4
3032741 | Level 4
3032744 | Level 4
3032746 | Level 4
3032748 | Level 4
3032755 | Level 4
3032758 | Level 4
3032761 | Level 4
3032763 | Level 4
3032765 | Level 4
3032771 | Level 4
3032774 | Level 4
3032779 | Level 4
3032782 | Level 4
3032785 | Level 4
3032787 | Level 4
3032789 | Level 4
3032793 | Level 4
3032800 | Level 4
3032803 | Level 4
3032809 | Level 4
3032812 | Level 4
3032815 | Level 4
3032819 | Level 4
3032823 | Level 4
3032827 | Level 4
3032834 | Level 4
3032837 | Level 4
3032843 | Level 4
3032846 | Level 4
3032849 | Level 4
3032853 | Level 4
3032857 | Level 4
3032859 | Level 4
3032866 | Level 4
3032869 | Level 4
3032875 | Level 4
3032878 | Level 4
3032881 | Level 4
3032885 | Level 4
3032889 | Level 4
3032893 | Level 4
3032899 | Level 4
3032912 | Level 4
3032921 | Level 4
3032934 | Level 4
3032938 | Level 4
3033752 | Level 5
3033796 | Level 5
3033816 | Level 5
3033819 | Level 5
3033824 | Level 5
3033826 | Level 5
3033830 | Level 5
3033833 | Level 5
3033837 | Level 5
3033840 | Level 5
3033843 | Level 5
3033845 | Level 5
3033848 | Level 5
3033850 | Level 5
3033917 | Level 5
3033927 | Level 5
3033966 | Level 5
3033980 | Level 5
3033983 | Level 5
3033986 | Level 5
3033990 | Level 5
3033993 | Level 5
3033997 | Level 5
3034000 | Level 5
3034003 | Level 5
3034005 | Level 5
3034007 | Level 5
3034012 | Level 5
3034014 | Level 5
3034082 | Level 5
3034127 | Level 5
3034130 | Level 5
3034134 | Level 5
3034146 | Level 5
3034149 | Level 5
3034154 | Level 5
3034156 | Level 5
3034160 | Level 5
3034163 | Level 5
3034167 | Level 5
3034170 | Level 5
3034173 | Level 5
3034175 | Level 5
3034178 | Level 5
3034182 | Level 5
3034254 | Level 5
3034264 | Level 5
3034302 | Level 5
3034312 | Level 5
3034315 | Level 5
3034320 | Level 5
3034322 | Level 5
3034326 | Level 5
3034329 | Level 5
3034333 | Level 5
3034336 | Level 5
3034339 | Level 5
3034341 | Level 5
3034344 | Level 5
3034368 | Level 5
3034371 | Level 5
3034376 | Level 5
3034378 | Level 5
3034380 | Level 5
3034384 | Level 5
3034387 | Level 5
3034390 | Level 5
3034394 | Level 5
3034397 | Level 5
3034402 | Level 5
3034406 | Level 5
3034426 | Level 5
3034429 | Level 5
3034432 | Level 5
3034434 | Level 5
3034443 | Level 5
3034446 | Level 5
3034449 | Level 5
3034451 | Level 5
3034460 | Level 5
3034463 | Level 5
3034466 | Level 5
3034468 | Level 5
3034477 | Level 5
3034480 | Level 5
3034483 | Level 5
3034485 | Level 5
3034491 | Level 5
3034494 | Level 5
3034497 | Level 5
3034500 | Level 5
3034511 | Level 5
3034513 | Level 5
3034515 | Level 5
3034517 | Level 5
3034520 | Level 5
3034522 | Level 5
3034524 | Level 5
3034527 | Level 5
3034531 | Level 5
3034533 | Level 5
3034535 | Level 5
3034538 | Level 5
3034544 | Level 5
3034546 | Level 5
3034549 | Level 5
3034554 | Level 5
3034556 | Level 5
3034561 | Level 5
3034565 | Level 5
3034567 | Level 5
3034571 | Level 5
3034578 | Level 5
3034584 | Level 5
3034586 | Level 5
3034590 | Level 5
3034593 | Level 5
3034596 | Level 5
3034598 | Level 5
3034600 | Level 5
3034602 | Level 5
3034605 | Level 5
3034614 | Level 5
3034617 | Level 5
3034620 | Level 5
3034623 | Level 5
3034626 | Level 5
3034628 | Level 5
3034630 | Level 5
3034632 | Level 5
3034636 | Level 5
3034638 | Level 5
3034640 | Level 5
3034645 | Level 5
3034647 | Level 5
3034649 | Level 5
3034652 | Level 5
3034660 | Level 5
3034666 | Level 5
3034669 | Level 5
3034671 | Level 5
3034676 | Level 5
3034678 | Level 5
3034680 | Level 5
3034684 | Level 5
3034686 | Level 5
3034690 | Level 5
3034692 | Level 5
3034705 | Level 5
3034708 | Level 5
3034711 | Level 5
3034713 | Level 5
3034715 | Level 5
3034721 | Level 5
3034727 | Level 5
3034729 | Level 5
3034733 | Level 5
3034735 | Level 5
3034737 | Level 5
3034739 | Level 5
3034755 | Level 5
3034761 | Level 5
3034763 | Level 5
3034765 | Level 5
3034769 | Level 5
3034771 | Level 5
3034774 | Level 5
3034778 | Level 5
3034780 | Level 5
3034783 | Level 5
3034787 | Level 5
3034796 | Level 5
3034799 | Level 5
3034801 | Level 5
3034806 | Level 5
3034812 | Level 5
3034814 | Level 5
3034816 | Level 5
3034819 | Level 5
3034821 | Level 5
3034823 | Level 5
3034831 | Level 5
3034834 | Level 5
3034837 | Level 5
3034839 | Level 5
3034841 | Level 5
3034843 | Level 5
3034845 | Level 5
3034849 | Level 5
3034851 | Level 5
3034854 | Level 5
3034856 | Level 5
3034858 | Level 5
3034866 | Level 5
3034870 | Level 5
3034874 | Level 5
3034876 | Level 5
3034878 | Level 5
3034883 | Level 5
3034886 | Level 5
3034888 | Level 5
3034890 | Level 5
3034893 | Level 5
3034895 | Level 5
3034900 | Level 5
3034902 | Level 5
3034905 | Level 5
3034909 | Level 5
3034912 | Level 5
3034914 | Level 5
3034920 | Level 5
3034922 | Level 5
3034928 | Level 5
3034932 | Level 5
3034934 | Level 5
3034936 | Level 5
3034939 | Level 5
3034949 | Level 5
3034952 | Level 5
3034955 | Level 5
3034957 | Level 5
3034959 | Level 5
3034961 | Level 5
3034965 | Level 5
3034967 | Level 5
3034970 | Level 5
3034972 | Level 5
3034974 | Level 5
3034976 | Level 5
3034982 | Level 5
3035001 | Level 5
3035004 | Level 5
3035007 | Level 5
3035009 | Level 5
3035014 | Level 5
3035017 | Level 5
3035019 | Level 5
3035021 | Level 5
3035028 | Level 5
3035030 | Level 5
3035032 | Level 5
3035034 | Level 5
3035039 | Level 5
3035041 | Level 5
3035044 | Level 5
3035046 | Level 5
3035048 | Level 5
3035050 | Level 5
3035052 | Level 5
3035056 | Level 5
3035058 | Level 5
3035060 | Level 5
3035062 | Level 5
3035066 | Level 5
3035076 | Level 5
3035081 | Level 5
3035086 | Level 5
3035092 | Level 5
3035097 | Level 5
3035102 | Level 5
3035108 | Level 5
3035114 | Level 5
3035119 | Level 5
3035121 | Level 5
3035123 | Level 5
3035125 | Level 5
3035130 | Level 5
3035132 | Level 5
3035134 | Level 5
3035136 | Level 5
3035141 | Level 5
3035143 | Level 5
3035145 | Level 5
3035150 | Level 5
3035152 | Level 5
3035154 | Level 5
3035159 | Level 5
3035161 | Level 5
3035163 | Level 5
3035170 | Level 5
3035173 | Level 5
3035176 | Level 5
3035180 | Level 5
3035182 | Level 5
3035187 | Level 5
3035190 | Level 5
3035193 | Level 5
3035195 | Level 5
3035197 | Level 5
3035204 | Level 5
3035207 | Level 5
3035210 | Level 5
3035214 | Level 5
3035216 | Level 5
3035221 | Level 5
3035224 | Level 5
3035227 | Level 5
3035229 | Level 5
3035235 | Level 5
3035240 | Level 5
3035243 | Level 5
3035246 | Level 5
3035250 | Level 5
3035257 | Level 5
3035260 | Level 5
3035263 | Level 5
3035267 | Level 5
3035273 | Level 5
3035276 | Level 5
3035281 | Level 5
3035284 | Level 5
3035286 | Level 5
3035292 | Level 5
3035297 | Level 5
3035300 | Level 5
3035303 | Level 5
3035307 | Level 5
3035312 | Level 5
3035315 | Level 5
3035318 | Level 5
3035320 | Level 5
3035322 | Level 5
3035329 | Level 5
3035332 | Level 5
3035335 | Level 5
3035337 | Level 5
3035339 | Level 5
3035346 | Level 5
3035349 | Level 5
3035352 | Level 5
3035354 | Level 5
3035356 | Level 5
3035362 | Level 5
3035365 | Level 5
3035370 | Level 5
3035373 | Level 5
3035376 | Level 5
3035378 | Level 5
3035380 | Level 5
3035384 | Level 5
3035391 | Level 5
3035394 | Level 5
3035400 | Level 5
3035403 | Level 5
3035406 | Level 5
3035410 | Level 5
3035414 | Level 5
3035418 | Level 5
3035425 | Level 5
3035428 | Level 5
3035434 | Level 5
3035437 | Level 5
3035440 | Level 5
3035444 | Level 5
3035448 | Level 5
3035450 | Level 5
3035457 | Level 5
3035460 | Level 5
3035466 | Level 5
3035469 | Level 5
3035472 | Level 5
3035476 | Level 5
3035480 | Level 5
3035484 | Level 5
3035490 | Level 5
3035503 | Level 5
3035512 | Level 5
3035525 | Level 5
3035529 | Level 5

# IfcCableCarrierFitting: Conduit Elbow - Plain End - PVC:Standard (998)
Type - Material: <Unnamed>
Pset_CableCarrierFittingTypeCommon - Reference: Standard; sets with these values: 2
Name (Conduit Elbow - Plain End - PVC:Standard:...) | In
1489315 | Level 2
1489356 | Level 2
1489360 | Level 2
1489362 | Level 2
1489494 | Level 2
1490102 | Level 2
1490132 | Level 2
1490134 | Level 2
1492542 | Level 2
1492544 | Level 2
1492546 | Level 2
1494426 | Level 2
1494478 | Level 2
1494480 | Level 2
1494940 | Level 2
1495067 | Level 2
1496699 | Level 2
1496701 | Level 2
1497044 | Level 2
1517383 | Level 2
1519532 | Level 2
1519557 | Level 2
1522226 | Level 2
1522416 | Level 2
1522611 | Level 2
1522647 | Level 2
1523057 | Level 2
1523082 | Level 2
1527648 | Level 2
1527651 | Level 2
1527653 | Level 2
1527695 | Level 2
1527697 | Level 2
1527699 | Level 2
1527729 | Level 2
1527731 | Level 2
1527770 | Level 2
1527774 | Level 2
1527825 | Level 2
1527827 | Level 2
1527869 | Level 2
1527873 | Level 2
1533002 | Level 2
1533175 | Level 2
1533215 | Level 2
1533217 | Level 2
1533219 | Level 2
1533244 | Level 2
1533246 | Level 2
1533248 | Level 2
1533253 | Level 2
1533264 | Level 2
1533266 | Level 2
1533268 | Level 2
1533277 | Level 2
1533279 | Level 2
1533283 | Level 2
1533314 | Level 2
1533316 | Level 2
1533326 | Level 2
1533358 | Level 2
1533362 | Level 2
1533407 | Level 2
1534614 | Level 2
1535016 | Level 2
1535018 | Level 2
1535877 | Level 2
1536140 | Level 2
1536321 | Level 2
1538491 | Level 2
1538924 | Level 2
1540285 | Level 2
1540296 | Level 2
1540307 | Level 2
1540319 | Level 2
1540347 | Level 2
1540351 | Level 2
1540495 | Level 2
1540577 | Level 2
1540610 | Level 2
1540619 | Level 2
1540623 | Level 2
1540635 | Level 2
1540663 | Level 2
1540667 | Level 2
1541795 | Level 2
1541797 | Level 2
1541835 | Level 2
1541837 | Level 2
1541839 | Level 2
1541864 | Level 2
1541866 | Level 2
1541884 | Level 2
1541886 | Level 2
1541888 | Level 2
1541897 | Level 2
1541899 | Level 2
1541903 | Level 2
1541927 | Level 2
1541929 | Level 2
1541939 | Level 2
1541943 | Level 2
1541969 | Level 2
1541973 | Level 2
1542627 | Level 2
1552299 | Level 2
1554470 | Nivel 1
1554472 | Nivel 1
1554504 | Nivel 1
1554529 | Nivel 1
1554547 | Nivel 1
1554634 | Nivel 1
1554664 | Nivel 1
1555073 | Nivel 1
1555098 | Nivel 1
1555100 | Nivel 1
1555120 | Nivel 1
1555133 | Nivel 1
1555137 | Nivel 1
1555203 | Nivel 1
1555278 | Nivel 1
1555304 | Nivel 1
1555308 | Nivel 1
1555318 | Nivel 1
1555350 | Nivel 1
1555376 | Nivel 1
1555380 | Nivel 1
1555517 | Nivel 1
1555559 | Nivel 1
1555561 | Nivel 1
1555608 | Nivel 1
1555625 | Nivel 1
1555659 | Nivel 1
1555693 | Nivel 1
1555750 | Nivel 1
1556251 | Nivel 1
1556295 | Nivel 1
1556297 | Nivel 1
1556361 | Nivel 1
1556401 | Nivel 1
1557025 | Nivel 1
1557205 | Nivel 1
1557219 | Nivel 1
1557245 | Nivel 1
1557249 | Nivel 1
1558090 | Nivel 1
1558127 | Level 2
1558129 | Level 2
1561164 | Nivel 1
1561216 | Nivel 1
1567077 | Nivel 1
1570328 | Nivel 1
1588732 | Level 6
1588734 | Level 6
1588830 | Level 6
1588888 | Level 6
1588892 | Level 6
1589119 | Level 6
1589121 | Level 6
1589148 | Level 6
1589168 | Level 6
1589207 | Level 6
1589237 | Level 6
1589282 | Level 6
1589308 | Level 6
1589312 | Level 6
1589351 | Level 6
1589377 | Level 6
1589381 | Level 6
1589507 | Level 6
1589543 | Level 6
1589545 | Level 6
1589562 | Level 6
1589580 | Level 6
1589607 | Level 6
1589664 | Level 6
1589853 | Level 6
1589892 | Level 6
1589907 | Level 6
1589925 | Level 6
1590038 | Level 6
1590060 | Level 6
1590072 | Level 6
1590098 | Level 6
1590102 | Level 6
1590154 | Level 6
1590156 | Level 6
1590196 | Level 6
1590198 | Level 6
1590224 | Level 6
1665446 | Level 2
1673589 | Level 2
1674278 | Level 2
1683719 | Level 2
1800657 | Level 2
1800709 | Level 2
1805961 | Level 2
1807378 | Level 2
1818809 | Level 2
1818812 | Level 2
1830551 | Level 2
1985218 | Level 2
2006019 | Nivel 1
2006021 | Nivel 1
2006023 | Nivel 1
2006091 | Nivel 1
2006128 | Nivel 1
2006132 | Nivel 1
2006137 | Nivel 1
2006146 | Nivel 1
2006157 | Nivel 1
2006164 | Nivel 1
2006173 | Nivel 1
2006893 | Nivel 1
2010205 | Nivel 1
2010207 | Nivel 1
2010743 | Nivel 1
2023239 | Level 2
2024202 | Level 2
2036867 | Nivel 1
2036871 | Nivel 1
2040178 | Nivel 1
2069853 | Level 2
2074545 | Nivel 1
2074569 | Nivel 1
2074579 | Nivel 1
2074598 | Nivel 1
2074620 | Nivel 1
2074636 | Nivel 2
2074638 | Nivel 2
2074641 | Nivel 2
2074792 | Nivel 1
2082950 | Nivel 1
2083261 | Nivel 1
2085079 | Nivel 1
2085275 | Nivel 1
2085399 | Nivel 1
2085419 | Nivel 1
2100427 | Nivel 1
2103201 | Nivel 1
2103363 | Nivel 1
2118035 | Level 2
2124259 | Nivel 1
2124261 | Nivel 1
2124306 | Nivel 1
2124329 | Nivel 1
2125334 | Nivel 1
2125337 | Nivel 1
2125494 | Nivel 1
2130047 | Nivel 1
2130477 | Nivel 1
2130479 | Nivel 1
2133279 | Nivel 1
2135822 | Nivel 2
2136407 | Nivel 1
2136515 | Nivel 1
2136519 | Nivel 1
2144492 | Level 2
2156889 | Level 2
2161294 | Nivel 1
2161305 | Nivel 1
2161312 | Nivel 1
2161325 | Nivel 1
2208672 | Level 2
2210042 | Nivel 1
2210052 | Nivel 1
2210062 | Nivel 1
2210084 | Nivel 1
2210101 | Nivel 1
2210103 | Nivel 1
2210115 | Nivel 1
2210127 | Nivel 1
2210129 | Nivel 1
2210144 | Nivel 1
2210146 | Nivel 1
2210165 | Nivel 1
2210169 | Nivel 2
2210207 | Nivel 1
2210209 | Nivel 1
2210212 | Nivel 1
2210216 | Nivel 1
2210275 | Nivel 1
2210290 | Nivel 1
2210300 | Nivel 1
2210361 | Nivel 1
2236891 | Level 2
2237508 | Level 6
2237510 | Level 6
2237547 | Nivel 6
2237572 | Level 6
2237595 | Level 6
2237597 | Level 6
2237607 | Level 6
2237611 | Level 6
2237622 | Level 6
2237632 | Nivel 6
2237634 | Level 6
2237693 | Level 6
2237729 | Level 6
2237735 | Level 6
2237737 | Level 6
2237772 | Level 6
2237786 | Level 6
2237917 | Level 6
2237942 | Level 6
2237963 | Level 6
2237965 | Level 6
2238009 | Level 6
2238242 | Level 6
2240152 | Level 6
2240331 | Level 6
2240833 | Level 6
2243122 | Level 6
2243741 | Level 6
2243743 | Level 6
2243945 | Level 6
2245247 | Level 6
2250890 | Level 2
2250897 | Level 2
2250905 | Level 2
2273557 | Level 6
2273559 | Level 6
2273561 | Level 6
2273585 | Level 6
2273674 | Level 6
2273695 | Level 6
2273764 | Level 6
2273779 | Level 6
2285871 | Level 6
2287336 | Level 6
2287363 | Level 6
2288754 | Level 6
2288840 | Level 6
2289663 | Level 6
2292807 | Level 6
2292809 | Level 6
2293072 | Level 6
2293074 | Level 6
2293077 | Level 6
2294753 | Level 6
2296000 | Level 6
2297830 | Level 6
2297834 | Level 6
2297847 | Level 6
2300886 | Level 6
2317154 | Level 6
2317225 | Level 6
2318781 | Level 6
2318784 | Level 6
2320104 | Level 6
2320432 | Level 6
2321360 | Level 6
2321740 | Level 6
2323415 | Level 6
2324379 | Level 6
2324381 | Level 6
2324686 | Level 6
2324998 | Level 6
2327724 | Level 6
2327726 | Level 6
2328871 | Level 6
2328877 | Level 6
2328879 | Level 6
2329759 | Level 6
2329784 | Level 6
2332132 | Level 6
2332629 | Level 6
2333664 | Level 6
2335831 | Level 6
2335835 | Level 6
2351270 | Level 6
2365616 | Nivel 1
2366413 | Nivel 1
2367705 | Nivel 1
2371166 | Nivel 1
2371665 | Nivel 1
2372132 | Nivel 1
2376116 | Nivel 1
2376123 | Nivel 1
2376127 | Nivel 1
2376538 | Nivel 1
2376699 | Nivel 1
2378756 | Nivel 1
2380712 | Nivel 1
2380716 | Nivel 1
2380718 | Nivel 1
2380722 | Nivel 1
2380724 | Nivel 1
2380726 | Nivel 1
2380728 | Nivel 1
2380730 | Nivel 1
2380732 | Nivel 1
2380734 | Nivel 1
2381617 | Level 6
2381627 | Level 6
2381742 | Level 6
2381746 | Level 6
2381748 | Level 6
2381752 | Level 6
2381754 | Level 6
2381756 | Level 6
2381758 | Level 6
2381760 | Level 6
2381762 | Level 6
2381764 | Level 6
2383174 | Level 6
2383599 | Level 6
2383656 | Level 6
2385427 | Level 6
2385486 | Level 6
2386873 | Level 6
2387149 | Level 6
2406072 | Level 2
2453175 | Nivel 1
2455384 | Level 6
2455387 | Level 6
2458991 | Level 2
2458993 | Level 2
2462124 | Level 2
2464266 | Level 2
2468854 | Nivel 1
2468857 | Nivel 1
2470603 | Nivel 1
2470606 | Nivel 1
2470716 | Nivel 1
2470719 | Nivel 1
2475718 | Level 6
2475721 | Level 6
2478843 | Level 6
2478845 | Level 6
2478888 | Level 6
2478891 | Level 6
2524008 | Level 2
2524498 | Level 2
2524500 | Level 2
2526509 | Level 2
2528267 | Level 2
2531939 | Level 2
2532477 | Level 2
2532984 | Level 2
2533699 | Level 2
2534059 | Level 2
2534121 | Level 2
2540847 | Level 2
2563424 | Level 2
2563682 | Level 2
2563684 | Level 2
2575605 | Level 2
2575649 | Level 2
2577713 | Level 2
2577764 | Level 2
2579647 | Nivel 1
2581263 | Level 6
2581290 | Level 6
2583083 | Nivel 1
2583235 | Level 6
2587561 | Nivel 1
2589773 | Level 6
2589809 | Level 6
2591564 | Level 6
2594265 | Nivel 1
2598226 | Level 2
2599070 | Level 2
2600873 | Level 2
2601040 | Level 2
2601069 | Level 2
2603533 | Level 2
2606737 | Level 2
2611078 | Nivel 1
2611105 | Nivel 1
2612532 | Nivel 1
2612563 | Nivel 1
2614566 | Nivel 1
2614589 | Nivel 1
2616426 | Nivel 1
2616445 | Nivel 1
2619367 | Level 6
2619397 | Level 6
2619509 | Level 6
2619534 | Level 6
2619666 | Level 6
2619691 | Level 6
2619809 | Level 6
2619838 | Level 6
2619991 | Level 2
2620016 | Level 2
2623088 | Level 2
2624836 | Nivel 1
2626298 | Nivel 1
2627834 | Nivel 1
2629364 | Nivel 1
2631077 | Level 6
2633228 | Level 6
2635304 | Level 6
2636898 | Level 6
2648005 | Level 2
2648028 | Level 2
2648036 | Level 2
2652755 | Level 2
2652778 | Level 2
2653696 | Level 2
2657117 | Nivel 1
2657957 | Nivel 2
2657984 | Nivel 2
2658008 | Nivel 1
2658029 | Nivel 1
2658203 | Nivel 1
2659189 | Nivel 1
2659216 | Nivel 1
2659256 | Nivel 1
2659279 | Nivel 1
2659862 | Nivel 2
2660155 | Nivel 1
2660176 | Nivel 1
2660203 | Nivel 2
2660234 | Nivel 2
2660548 | Nivel 1
2661439 | Nivel 1
2661460 | Nivel 1
2661485 | Nivel 1
2661514 | Nivel 1
2663621 | Level 6
2663644 | Level 6
2663675 | Level 6
2663698 | Level 6
2664047 | Level 6
2664069 | Level 6
2664122 | Level 6
2664147 | Level 6
2664325 | Level 6
2665089 | Level 6
2665110 | Level 6
2665133 | Level 6
2665156 | Level 6
2665459 | Level 6
2665777 | Level 6
2665799 | Level 6
2665822 | Level 6
2665845 | Level 6
2670015 | Level 2
2681808 | Nivel 1
2719571 | Level 2
2745842 | Level 6
2745846 | Level 6
2745866 | Level 6
2786521 | Level 2
2814384 | Level 2
2817447 | Level 2
2834943 | Level 2
2847226 | Level 2
2856530 | Nivel 1
2858074 | Nivel 1
2858879 | Nivel 1
2864151 | Nivel 1
2864476 | Nivel 1
2868947 | Nivel 1
2870178 | Nivel 1
2870524 | Nivel 1
2875504 | Nivel 1
2875727 | Nivel 1
2879781 | Level 6
2881541 | Level 6
2881674 | Level 6
2887436 | Level 6
2891621 | Level 6
2891748 | Level 6
2893190 | Level 6
2894870 | Level 6
2895949 | Level 6
2909535 | Level 2
2956924 | Level 2
2966373 | Level 2
2981089 | Level 2
2984654 | Nivel 1
2987153 | Level 6
2987155 | Nivel 1
2990172 | Level 2
2994784 | Nivel 1
3025225 | Nivel 2
3025227 | Nivel 2
3025235 | Nivel 2
3025241 | Nivel 2
3025246 | Nivel 2
3025257 | Nivel 2
3025390 | Nivel 2
3025395 | Nivel 2
3025397 | Nivel 2
3025404 | Nivel 2
3025406 | Nivel 2
3025410 | Nivel 2
3025445 | Nivel 2
3025536 | Nivel 2
3025558 | Nivel 2
3025560 | Nivel 2
3025575 | Nivel 2
3025579 | Nivel 2
3025589 | Nivel 2
3025617 | Nivel 2
3025626 | Nivel 2
3025711 | Nivel 2
3025733 | Nivel 2
3025735 | Nivel 2
3025747 | Nivel 2
3025758 | Nivel 2
3025789 | Nivel 2
3025804 | Nivel 2
3025814 | Nivel 2
3025840 | Nivel 2
3025844 | Nivel 2
3025851 | Nivel 2
3025853 | Nivel 2
3025855 | Nivel 2
3025857 | Nivel 2
3025945 | Nivel 2
3025947 | Nivel 2
3025949 | Nivel 2
3025984 | Nivel 2
3026004 | Nivel 2
3026009 | Nivel 2
3026016 | Nivel 2
3026021 | Nivel 2
3026025 | Nivel 2
3026031 | Nivel 2
3026062 | Nivel 2
3026064 | Nivel 2
3026068 | Nivel 2
3026101 | Nivel 2
3026113 | Nivel 2
3026117 | Nivel 2
3026125 | Nivel 2
3026135 | Nivel 2
3026146 | Nivel 2
3026158 | Nivel 2
3026160 | Nivel 2
3026181 | Nivel 2
3026184 | Nivel 2
3026188 | Nivel 2
3026190 | Nivel 2
3026215 | Nivel 2
3026221 | Nivel 2
3026223 | Nivel 2
3026231 | Nivel 2
3026233 | Nivel 2
3026260 | Nivel 2
3026267 | Nivel 2
3026269 | Nivel 2
3026271 | Nivel 2
3026281 | Nivel 2
3026287 | Nivel 2
3026289 | Nivel 2
3026329 | Nivel 2
3026348 | Nivel 2
3026352 | Nivel 2
3026361 | Nivel 2
3026369 | Nivel 2
3026388 | Nivel 2
3026402 | Nivel 2
3026411 | Nivel 2
3026413 | Nivel 2
3026421 | Nivel 2
3026423 | Nivel 2
3026438 | Nivel 2
3026461 | Nivel 2
3026480 | Nivel 2
3026486 | Nivel 2
3026491 | Nivel 2
3026567 | Nivel 2
3026571 | Nivel 2
3026573 | Nivel 2
3026575 | Nivel 2
3026582 | Nivel 2
3026591 | Nivel 2
3026593 | Nivel 2
3026607 | Nivel 2
3026609 | Nivel 2
3026613 | Nivel 2
3026615 | Nivel 2
3026668 | Nivel 2
3026681 | Nivel 2
3026702 | Nivel 2
3026715 | Nivel 2
3026734 | Nivel 2
3026736 | Nivel 2
3026751 | Nivel 2
3026755 | Nivel 2
3026768 | Nivel 2
3026772 | Nivel 2
3026791 | Nivel 2
3026793 | Nivel 2
3026808 | Nivel 2
3026827 | Nivel 2
3026844 | Nivel 2
3026861 | Nivel 2
3026885 | Nivel 2
3026889 | Nivel 2
3026911 | Nivel 2
3026915 | Nivel 2
3026919 | Nivel 2
3026923 | Nivel 2
3026945 | Nivel 2
3026949 | Nivel 2
3026955 | Nivel 2
3026977 | Nivel 2
3026981 | Nivel 2
3026985 | Nivel 2
3026989 | Nivel 2
3026996 | Nivel 2
3027000 | Nivel 2
3027003 | Nivel 2
3027010 | Nivel 2
3027014 | Nivel 2
3027019 | Nivel 2
3027023 | Nivel 2
3027026 | Nivel 2
3027033 | Nivel 2
3027039 | Nivel 2
3027042 | Nivel 2
3027045 | Nivel 2
3031199 | Level 4
3031201 | Level 4
3031209 | Level 4
3031215 | Level 4
3031220 | Level 4
3031231 | Level 4
3031364 | Level 4
3031369 | Level 4
3031371 | Level 4
3031378 | Level 4
3031380 | Level 4
3031384 | Level 4
3031419 | Level 4
3031508 | Level 4
3031530 | Level 4
3031532 | Level 4
3031547 | Level 4
3031551 | Level 4
3031561 | Level 4
3031589 | Level 4
3031598 | Level 4
3031680 | Level 4
3031702 | Level 4
3031704 | Level 4
3031716 | Level 4
3031727 | Level 4
3031758 | Level 4
3031773 | Level 4
3031783 | Level 4
3031809 | Level 4
3031813 | Level 4
3031820 | Level 4
3031822 | Level 4
3031824 | Level 4
3031826 | Level 4
3031912 | Level 4
3031914 | Level 4
3031916 | Level 4
3031949 | Level 4
3031968 | Level 4
3031972 | Level 4
3031978 | Level 4
3031982 | Level 4
3031985 | Level 4
3031991 | Level 4
3032016 | Level 4
3032018 | Level 4
3032021 | Level 4
3032051 | Level 4
3032063 | Level 4
3032066 | Level 4
3032073 | Level 4
3032082 | Level 4
3032091 | Level 4
3032103 | Level 4
3032105 | Level 4
3032126 | Level 4
3032128 | Level 4
3032132 | Level 4
3032134 | Level 4
3032152 | Level 4
3032158 | Level 4
3032160 | Level 4
3032166 | Level 4
3032168 | Level 4
3032194 | Level 4
3032199 | Level 4
3032201 | Level 4
3032203 | Level 4
3032212 | Level 4
3032217 | Level 4
3032219 | Level 4
3032256 | Level 4
3032271 | Level 4
3032273 | Level 4
3032281 | Level 4
3032289 | Level 4
3032306 | Level 4
3032316 | Level 4
3032325 | Level 4
3032327 | Level 4
3032333 | Level 4
3032335 | Level 4
3032350 | Level 4
3032372 | Level 4
3032389 | Level 4
3032394 | Level 4
3032397 | Level 4
3032473 | Level 4
3032477 | Level 4
3032479 | Level 4
3032481 | Level 4
3032488 | Level 4
3032497 | Level 4
3032499 | Level 4
3032513 | Level 4
3032515 | Level 4
3032519 | Level 4
3032521 | Level 4
3032574 | Level 4
3032587 | Level 4
3032608 | Level 4
3032621 | Level 4
3032640 | Level 4
3032642 | Level 4
3032657 | Level 4
3032661 | Level 4
3032674 | Level 4
3032678 | Level 4
3032697 | Level 4
3032699 | Level 4
3032714 | Level 4
3032733 | Level 4
3032750 | Level 4
3032767 | Level 4
3032791 | Level 4
3032795 | Level 4
3032817 | Level 4
3032821 | Level 4
3032825 | Level 4
3032829 | Level 4
3032851 | Level 4
3032855 | Level 4
3032861 | Level 4
3032883 | Level 4
3032887 | Level 4
3032891 | Level 4
3032895 | Level 4
3032901 | Level 4
3032905 | Level 4
3032908 | Level 4
3032914 | Level 4
3032918 | Level 4
3032923 | Level 4
3032927 | Level 4
3032930 | Level 4
3032936 | Level 4
3032942 | Level 4
3032945 | Level 4
3032948 | Level 4
3033790 | Level 5
3033792 | Level 5
3033800 | Level 5
3033806 | Level 5
3033811 | Level 5
3033822 | Level 5
3033955 | Level 5
3033960 | Level 5
3033962 | Level 5
3033969 | Level 5
3033971 | Level 5
3033975 | Level 5
3034010 | Level 5
3034099 | Level 5
3034121 | Level 5
3034123 | Level 5
3034138 | Level 5
3034142 | Level 5
3034152 | Level 5
3034180 | Level 5
3034189 | Level 5
3034271 | Level 5
3034293 | Level 5
3034295 | Level 5
3034307 | Level 5
3034318 | Level 5
3034349 | Level 5
3034364 | Level 5
3034374 | Level 5
3034400 | Level 5
3034404 | Level 5
3034411 | Level 5
3034413 | Level 5
3034415 | Level 5
3034417 | Level 5
3034503 | Level 5
3034505 | Level 5
3034507 | Level 5
3034540 | Level 5
3034559 | Level 5
3034563 | Level 5
3034569 | Level 5
3034573 | Level 5
3034576 | Level 5
3034582 | Level 5
3034607 | Level 5
3034609 | Level 5
3034612 | Level 5
3034642 | Level 5
3034654 | Level 5
3034657 | Level 5
3034664 | Level 5
3034673 | Level 5
3034682 | Level 5
3034694 | Level 5
3034696 | Level 5
3034717 | Level 5
3034719 | Level 5
3034723 | Level 5
3034725 | Level 5
3034743 | Level 5
3034749 | Level 5
3034751 | Level 5
3034757 | Level 5
3034759 | Level 5
3034785 | Level 5
3034790 | Level 5
3034792 | Level 5
3034794 | Level 5
3034803 | Level 5
3034808 | Level 5
3034810 | Level 5
3034847 | Level 5
3034862 | Level 5
3034864 | Level 5
3034872 | Level 5
3034880 | Level 5
3034897 | Level 5
3034907 | Level 5
3034916 | Level 5
3034918 | Level 5
3034924 | Level 5
3034926 | Level 5
3034941 | Level 5
3034963 | Level 5
3034980 | Level 5
3034985 | Level 5
3034988 | Level 5
3035064 | Level 5
3035068 | Level 5
3035070 | Level 5
3035072 | Level 5
3035079 | Level 5
3035088 | Level 5
3035090 | Level 5
3035104 | Level 5
3035106 | Level 5
3035110 | Level 5
3035112 | Level 5
3035165 | Level 5
3035178 | Level 5
3035199 | Level 5
3035212 | Level 5
3035231 | Level 5
3035233 | Level 5
3035248 | Level 5
3035252 | Level 5
3035265 | Level 5
3035269 | Level 5
3035288 | Level 5
3035290 | Level 5
3035305 | Level 5
3035324 | Level 5
3035341 | Level 5
3035358 | Level 5
3035382 | Level 5
3035386 | Level 5
3035408 | Level 5
3035412 | Level 5
3035416 | Level 5
3035420 | Level 5
3035442 | Level 5
3035446 | Level 5
3035452 | Level 5
3035474 | Level 5
3035478 | Level 5
3035482 | Level 5
3035486 | Level 5
3035492 | Level 5
3035496 | Level 5
3035499 | Level 5
3035505 | Level 5
3035509 | Level 5
3035514 | Level 5
3035518 | Level 5
3035521 | Level 5
3035527 | Level 5
3035533 | Level 5
3035536 | Level 5
3035539 | Level 5

# IfcCableCarrierSegment: Conduit with Fittings:PVC (4616)
Type - PredefinedType: CONDUITSEGMENT
Classification: D5020.30 Uniformat (Uniformat)
Pset_CableCarrierSegmentTypeCommon - Reference: PVC; sets with these values: 2
Name (Conduit with Fittings:PVC:...) | In | Length (m) | CrossSectionArea (m2) | OuterSurfaceArea (m2)
1489167 | Level 2 | 0.26665 | 0.000261727 | 0.0152934
1489169 | Level 2 | 0.2426 | 0.000261727 | 0.013914
1489171 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1489175 | Level 2 | 1.1426 | 0.000261727 | 0.0655323
1489177 | Level 2 | 0.7926 | 0.000261727 | 0.0454585
1489179 | Level 2 | 0.7926 | 0.000261727 | 0.0454585
1489181 | Level 2 | 2.4836 | 0.000261717 | 0.142444
1489184 | Level 2 | 1.8555 | 0.000261727 | 0.10642
1489192 | Level 2 | 0.615816 | 0.000261727 | 0.0353193
1489199 | Level 2 | 0.998002 | 0.000261727 | 0.0572391
1489201 | Level 2 | 0.448 | 0.000261727 | 0.0256945
1489203 | Level 2 | 0.2426 | 0.000261727 | 0.013914
1489205 | Level 2 | 0.2426 | 0.000261727 | 0.013914
1489208 | Level 2 | 0.665805 | 0.000261727 | 0.0381864
1489214 | Level 2 | 0.40497 | 0.000261727 | 0.0232265
1489218 | Level 2 | 0.998002 | 0.000261727 | 0.0572391
1489220 | Level 2 | 0.048 | 0.000261727 | 0.00275298
1489222 | Level 2 | 0.1026 | 0.000261727 | 0.00588449
1489232 | Level 2 | 0.7926 | 0.000261727 | 0.0454585
1489234 | Level 2 | 0.7555 | 0.000261727 | 0.0433307
1489242 | Level 2 | 0.0407999 | 0.000261727 | 0.00234002
1489244 | Level 2 | 0.2426 | 0.000261727 | 0.013914
1489246 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1489248 | Level 2 | 0.2426 | 0.000261727 | 0.013914
1489250 | Level 2 | 0.619405 | 0.000261727 | 0.0355252
1489254 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1489265 | Level 2 | 0.804767 | 0.000261727 | 0.0461564
1489267 | Level 2 | 0.8055 | 0.000261727 | 0.0461984
1489271 | Level 2 | 2.1564 | 0.000261727 | 0.123678
1489273 | Level 2 | 0.216402 | 0.000261727 | 0.0124114
1489277 | Level 2 | 0.197074 | 0.000261727 | 0.0113029
1489281 | Level 2 | 2.70501 | 0.000261727 | 0.155142
1489285 | Level 2 | 1.3965 | 0.000261727 | 0.0800944
1489287 | Level 2 | 0.589 | 0.000261727 | 0.0337813
1489289 | Level 2 | 1.0355 | 0.000261727 | 0.0593898
1489291 | Level 2 | 0.358965 | 0.000261727 | 0.020588
1489303 | Level 2 | 0.372047 | 0.000261727 | 0.0213382
1489305 | Level 2 | 0.0134098 | 0.000261727 | 0.000769101
1489311 | Level 2 | 1.11439 | 0.000445281 | 0.0833666
1489313 | Level 2 | 0.0318056 | 0.000445281 | 0.00237935
1489317 | Level 2 | 1.23982 | 0.000445265 | 0.0927499
1489319 | Level 2 | 0.22955 | 0.000261727 | 0.0131655
1489321 | Level 2 | 6.598 | 0.000445281 | 0.493591
1489325 | Level 2 | 0.1985 | 0.000445281 | 0.0148496
1489327 | Level 2 | 0.2055 | 0.000445281 | 0.0153733
1489329 | Level 2 | 0.602325 | 0.000445281 | 0.0450594
1489331 | Level 2 | 2.526 | 0.000445281 | 0.188968
1489333 | Level 2 | 1.34684 | 0.000261727 | 0.0772461
1489335 | Level 2 | 2.54633 | 0.000261727 | 0.146041
1489337 | Level 2 | 1.10235 | 0.000261727 | 0.0632241
1489342 | Level 2 | 0.2855 | 0.000261727 | 0.0163745
1489343 | Level 2 | 0.410325 | 0.000261727 | 0.0235336
1489345 | Level 2 | 0.246267 | 0.000261727 | 0.0141243
1489381 | Level 2 | 1.8475 | 0.000261727 | 0.105961
1489397 | Level 2 | 1.548 | 0.000261727 | 0.0887836
1489401 | Level 2 | 0.4481 | 0.000261727 | 0.0257002
1489415 | Level 2 | 0.22955 | 0.000261727 | 0.0131655
1489418 | Level 2 | 0.22955 | 0.000261727 | 0.0131655
1489423 | Level 2 | 0.8055 | 0.000261727 | 0.0461984
1489425 | Level 2 | 3.4873 | 0.000261727 | 0.20001
1489427 | Level 2 | 0.2035 | 0.000261727 | 0.0116715
1489470 | Level 2 | 0.255363 | 0.000261727 | 0.014646
1489471 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1489506 | Level 2 | 1.90536 | 0.000261727 | 0.10928
1489508 | Level 2 | 1.8555 | 0.000261727 | 0.10642
1489514 | Level 2 | 0.684767 | 0.000261727 | 0.0392739
1489516 | Level 2 | 1.06665 | 0.000261727 | 0.0611763
1489949 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1490044 | Level 2 | 0.1597 | 0.000261727 | 0.00915939
1490158 | Level 2 | 0.6725 | 0.000261717 | 0.0385704
1491067 | Level 2 | 0.1626 | 0.000261727 | 0.0093257
1492467 | Level 2 | 0.6457 | 0.000261727 | 0.0370333
1493508 | Level 2 | 0.0860071 | 0.000261727 | 0.00493282
1494382 | Level 2 | 0.1713 | 0.000261727 | 0.00982469
1495058 | Level 2 | 0.158503 | 0.000261727 | 0.00909073
1495658 | Level 2 | 0.706625 | 0.000261727 | 0.0405275
1496510 | Level 2 | 1.92988 | 0.000261727 | 0.110686
1496678 | Level 2 | 0.424815 | 0.000261717 | 0.0243647
1500114 | Level 2 | 1.49977 | 0.000677323 | 0.138375
1502487 | Level 2 | 1.4947 | 0.000677323 | 0.137908
1502488 | Level 2 | 1.49977 | 0.000677323 | 0.138375
1502489 | Level 2 | 0.0372834 | 0.000677323 | 0.00343994
1502490 | Level 2 | 1.48835 | 0.000677323 | 0.137323
1502491 | Level 2 | 0.0194631 | 0.000677323 | 0.00179576
1502492 | Level 2 | 1.48835 | 0.000677323 | 0.137323
1502493 | Level 2 | 0.0194631 | 0.000677323 | 0.00179576
1502494 | Level 2 | 1.48835 | 0.000677323 | 0.137323
1502495 | Level 2 | 0.0194631 | 0.000677323 | 0.00179576
1502496 | Level 2 | 1.48395 | 0.00113992 | 0.177621
1502497 | Level 2 | 0.0106493 | 0.00113992 | 0.00127467
1510330 | Level 2 | 1.48835 | 0.000677323 | 0.137323
1510475 | Level 2 | 0.0685086 | 0.000677323 | 0.00632092
1512387 | Level 2 | 0.0398222 | 0.000677323 | 0.00367418
1512576 | Level 2 | 1.46977 | 0.000677323 | 0.135607
1513688 | Level 2 | 1.4994 | 0.000677323 | 0.138341
1513689 | Level 2 | 0.0391972 | 0.000677323 | 0.00361651
1514012 | Level 2 | 1.45835 | 0.000677323 | 0.134555
1514024 | Level 2 | 1.48835 | 0.000677323 | 0.137323
1514025 | Level 2 | 0.0207519 | 0.000677323 | 0.00191466
1514049 | Level 2 | 1.45835 | 0.000677323 | 0.134555
1514061 | Level 2 | 1.48835 | 0.000677323 | 0.137323
1514062 | Level 2 | 0.0207519 | 0.000677323 | 0.00191466
1514086 | Level 2 | 1.45835 | 0.000677323 | 0.134555
1514098 | Level 2 | 1.48835 | 0.000677323 | 0.137323
1514099 | Level 2 | 0.0207519 | 0.000677323 | 0.00191466
1514123 | Level 2 | 1.46536 | 0.00113992 | 0.175396
1514135 | Level 2 | 1.49536 | 0.00113992 | 0.178986
1514136 | Level 2 | 0.0329672 | 0.00113992 | 0.003946
1514137 | Level 2 | 0.328155 | 0.00113992 | 0.0392784
1518576 | Level 2 | 0.992602 | 0.000261727 | 0.0569294
1518577 | Level 2 | 0.0163521 | 0.000261727 | 0.000937856
1519290 | Level 2 | 0.204702 | 0.000261727 | 0.0117404
1519399 | Level 2 | 0.616254 | 0.000261727 | 0.0353444
1519474 | Level 2 | 0.2175 | 0.000261727 | 0.0124744
1522076 | Level 2 | 0.00269577 | 0.000445281 | 0.000201668
1522079 | Level 2 | 0.0179324 | 0.000445281 | 0.00134151
1522082 | Level 2 | 0.00269577 | 0.000445281 | 0.000201668
1522158 | Level 2 | 2.23222 | 0.000445281 | 0.16699
1522295 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1522298 | Level 2 | 0.05 | 0.000261727 | 0.00286769
1522301 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1522384 | Level 2 | 0.583761 | 0.000261727 | 0.0334808
1522464 | Level 2 | 0.0186475 | 0.000261727 | 0.0010695
1522467 | Level 2 | 0.21625 | 0.000261727 | 0.0124027
1522470 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1522473 | Level 2 | 0.017729 | 0.000261727 | 0.00101682
1522563 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1522566 | Level 2 | 0.0179324 | 0.000261727 | 0.00102849
1522569 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1522586 | Level 2 | 0.291829 | 0.000261727 | 0.0167375
1522692 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1522695 | Level 2 | 0.0234188 | 0.000261727 | 0.00134315
1522698 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1522727 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1522730 | Level 2 | 0.0234188 | 0.000261727 | 0.00134315
1522733 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1522790 | Level 2 | 0.136901 | 0.000261727 | 0.00785178
1523008 | Level 2 | 1.77196 | 0.000261727 | 0.101629
1527565 | Level 2 | 0.26665 | 0.000261727 | 0.0152934
1527566 | Level 2 | 0.2426 | 0.000261727 | 0.013914
1527567 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1527569 | Level 2 | 1.1426 | 0.000261727 | 0.0655323
1527570 | Level 2 | 0.7926 | 0.000261727 | 0.0454585
1527571 | Level 2 | 0.7926 | 0.000261727 | 0.0454585
1527572 | Level 2 | 2.4836 | 0.000261717 | 0.142444
1527574 | Level 2 | 1.8555 | 0.000261727 | 0.10642
1527575 | Level 2 | 0.615816 | 0.000261727 | 0.0353193
1527577 | Level 2 | 0.998002 | 0.000261727 | 0.0572391
1527578 | Level 2 | 0.448 | 0.000261727 | 0.0256945
1527579 | Level 2 | 0.2426 | 0.000261727 | 0.013914
1527580 | Level 2 | 0.2426 | 0.000261727 | 0.013914
1527582 | Level 2 | 0.670984 | 0.000261727 | 0.0384834
1527583 | Level 2 | 1.5055 | 0.000261727 | 0.086346
1527585 | Level 2 | 0.40497 | 0.000261727 | 0.0232265
1527594 | Level 2 | 0.805065 | 0.000261727 | 0.0461735
1527595 | Level 2 | 0.805065 | 0.000261727 | 0.0461735
1527600 | Level 2 | 0.0407982 | 0.000261727 | 0.00233993
1527601 | Level 2 | 0.24265 | 0.000261727 | 0.0139169
1527602 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1527603 | Level 2 | 0.2426 | 0.000261727 | 0.013914
1527604 | Level 2 | 0.664382 | 0.000261727 | 0.0381048
1527605 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1527607 | Level 2 | 0.188414 | 0.000261727 | 0.0108062
1527612 | Level 2 | 0.767057 | 0.000261727 | 0.0439936
1527613 | Level 2 | 0.767057 | 0.000261727 | 0.0439936
1527616 | Level 2 | 1.7643 | 0.000261727 | 0.101189
1527621 | Level 2 | 0.917614 | 0.000261727 | 0.0526285
1527624 | Level 2 | 1.4165 | 0.000261727 | 0.0812415
1527625 | Level 2 | 1.4636 | 0.000261727 | 0.0839429
1527627 | Level 2 | 0.376193 | 0.000261727 | 0.0215761
1527628 | Level 2 | 1.3418 | 0.000261727 | 0.0769572
1527629 | Level 2 | 0.270852 | 0.000261727 | 0.0155344
1527633 | Level 2 | 0.00765078 | 0.000261727 | 0.000438801
1527640 | Level 2 | 1.15192 | 0.000261727 | 0.0660669
1527644 | Level 2 | 0.431722 | 0.000261727 | 0.0247608
1527646 | Level 2 | 0.241146 | 0.000261727 | 0.0138306
1527655 | Level 2 | 1.8475 | 0.000261727 | 0.105961
1527663 | Level 2 | 1.548 | 0.000261727 | 0.0887836
1527670 | Level 2 | 0.22955 | 0.000261727 | 0.0131655
1527671 | Level 2 | 0.22955 | 0.000261727 | 0.0131655
1527673 | Level 2 | 0.603627 | 0.000261727 | 0.0346202
1527674 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1527693 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1527694 | Level 2 | 0.1597 | 0.000261727 | 0.00915939
1527712 | Level 2 | 0.18675 | 0.000261727 | 0.0107108
1527728 | Level 2 | 0.6457 | 0.000261727 | 0.0370333
1527739 | Level 2 | 0.0835071 | 0.000261727 | 0.00478944
1527744 | Level 2 | 0.0910071 | 0.000261727 | 0.00521959
1527751 | Level 2 | 1.13942 | 0.000261727 | 0.06535
1527753 | Level 2 | 0.221183 | 0.000261727 | 0.0126857
1527773 | Level 2 | 0.158503 | 0.000261727 | 0.00909073
1527784 | Level 2 | 0.188812 | 0.000261727 | 0.0108291
1527818 | Level 2 | 0.992602 | 0.000261727 | 0.0569294
1527819 | Level 2 | 0.00725214 | 0.000261727 | 0.000415937
1527822 | Level 2 | 0.204702 | 0.000261727 | 0.0117404
1527823 | Level 2 | 0.119573 | 0.000261727 | 0.00685793
1527824 | Level 2 | 0.2175 | 0.000261727 | 0.0124744
1527845 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1527846 | Level 2 | 0.0234188 | 0.000261727 | 0.00134315
1527849 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1527852 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1527853 | Level 2 | 0.0234188 | 0.000261727 | 0.00134315
1527856 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1527859 | Level 2 | 0.0919011 | 0.000261727 | 0.00527087
1527868 | Level 2 | 1.77196 | 0.000261727 | 0.101629
1528150 | Level 2 | 0.285511 | 0.000261727 | 0.0163751
1532633 | Level 2 | 1.0555 | 0.000261727 | 0.0605368
1532634 | Level 2 | 0.809829 | 0.000261717 | 0.0464467
1533091 | Level 2 | 0.26665 | 0.000261727 | 0.0152934
1533092 | Level 2 | 0.2426 | 0.000261727 | 0.013914
1533093 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1533095 | Level 2 | 1.1426 | 0.000261727 | 0.0655323
1533096 | Level 2 | 0.7926 | 0.000261727 | 0.0454585
1533097 | Level 2 | 0.7926 | 0.000261727 | 0.0454585
1533098 | Level 2 | 2.4786 | 0.000261727 | 0.142157
1533100 | Level 2 | 1.8555 | 0.000261727 | 0.10642
1533101 | Level 2 | 0.615816 | 0.000261727 | 0.0353193
1533103 | Level 2 | 0.998002 | 0.000261727 | 0.0572391
1533104 | Level 2 | 0.448 | 0.000261727 | 0.0256945
1533105 | Level 2 | 0.2426 | 0.000261727 | 0.013914
1533106 | Level 2 | 0.2426 | 0.000261727 | 0.013914
1533108 | Level 2 | 0.6405 | 0.000261727 | 0.036735
1533109 | Level 2 | 1.5055 | 0.000261727 | 0.086346
1533111 | Level 2 | 0.40497 | 0.000261717 | 0.0232265
1533114 | Level 2 | 0.998002 | 0.000261727 | 0.0572391
1533115 | Level 2 | 0.048 | 0.000261727 | 0.00275298
1533116 | Level 2 | 0.1026 | 0.000261727 | 0.00588449
1533120 | Level 2 | 0.7926 | 0.000261727 | 0.0454585
1533121 | Level 2 | 0.7555 | 0.000261727 | 0.0433307
1533126 | Level 2 | 0.0408 | 0.000261727 | 0.00234003
1533127 | Level 2 | 0.24265 | 0.000261727 | 0.0139169
1533128 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1533130 | Level 2 | 0.619405 | 0.000261727 | 0.0355252
1533131 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1533132 | Level 2 | 1.09265 | 0.000261727 | 0.0626675
1533133 | Level 2 | 0.0141843 | 0.000261727 | 0.000813524
1533137 | Level 2 | 0.835065 | 0.000261727 | 0.0478941
1533138 | Level 2 | 0.7555 | 0.000261727 | 0.0433307
1533141 | Level 2 | 2.1564 | 0.000261727 | 0.123678
1533142 | Level 2 | 0.216402 | 0.000261727 | 0.0124114
1533145 | Level 2 | 0.677599 | 0.000261717 | 0.0388628
1533146 | Level 2 | 0.917614 | 0.000261727 | 0.0526285
1533147 | Level 2 | 2.70501 | 0.000261727 | 0.155142
1533149 | Level 2 | 1.44567 | 0.000261727 | 0.0829144
1533150 | Level 2 | 0.539 | 0.000261727 | 0.0309136
1533151 | Level 2 | 0.407586 | 0.000261727 | 0.0233766
1533157 | Level 2 | 0.189792 | 0.000261727 | 0.0108853
1533159 | Level 2 | 0.0193364 | 0.000261727 | 0.00110901
1533164 | Level 2 | 1.10235 | 0.000261727 | 0.0632241
1533167 | Level 2 | 0.324801 | 0.000261727 | 0.0186285
1533168 | Level 2 | 0.201247 | 0.000261727 | 0.0115423
1533169 | Level 2 | 0.0105436 | 0.000261727 | 0.000604714
1533172 | Level 2 | 0.0523645 | 0.000261727 | 0.0030033
1533177 | Level 2 | 1.8475 | 0.000261727 | 0.105961
1533187 | Level 2 | 0.4481 | 0.000261727 | 0.0257002
1533192 | Level 2 | 0.22955 | 0.000261727 | 0.0131655
1533193 | Level 2 | 0.22955 | 0.000261727 | 0.0131655
1533194 | Level 2 | 0.7555 | 0.000261727 | 0.0433307
1533195 | Level 2 | 3.48746 | 0.000261727 | 0.200019
1533196 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1533205 | Level 2 | 0.255065 | 0.000261727 | 0.0146289
1533206 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1533209 | Level 2 | 1.90507 | 0.000261727 | 0.109263
1533210 | Level 2 | 1.8555 | 0.000261727 | 0.10642
1533213 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1533214 | Level 2 | 0.1597 | 0.000261727 | 0.00915939
1533222 | Level 2 | 0.2492 | 0.000261727 | 0.0142925
1533229 | Level 2 | 0.1855 | 0.000261727 | 0.0106391
1533243 | Level 2 | 0.6457 | 0.000261727 | 0.0370333
1533250 | Level 2 | 0.0835071 | 0.000261717 | 0.00478944
1533255 | Level 2 | 0.0835071 | 0.000261727 | 0.00478944
1533263 | Level 2 | 0.1713 | 0.000261727 | 0.00982469
1533272 | Level 2 | 1.17191 | 0.000261727 | 0.0672131
1533282 | Level 2 | 0.158503 | 0.000261727 | 0.00909073
1533292 | Level 2 | 0.18877 | 0.000261727 | 0.0108266
1533307 | Level 2 | 0.992602 | 0.000261727 | 0.0569294
1533308 | Level 2 | 0.0158522 | 0.000261727 | 0.00090918
1533311 | Level 2 | 0.204702 | 0.000261727 | 0.0117404
1533312 | Level 2 | 0.616254 | 0.000261727 | 0.0353444
1533313 | Level 2 | 0.2175 | 0.000261727 | 0.0124744
1533318 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1533319 | Level 2 | 0.05 | 0.000261727 | 0.00286769
1533322 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1533325 | Level 2 | 0.103074 | 0.000261727 | 0.00591165
1533334 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1533335 | Level 2 | 0.0234188 | 0.000261727 | 0.00134315
1533338 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1533341 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1533342 | Level 2 | 0.0234188 | 0.000261727 | 0.00134315
1533345 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1533348 | Level 2 | 0.136901 | 0.000261727 | 0.00785178
1533357 | Level 2 | 1.77196 | 0.000261727 | 0.101629
1533400 | Level 2 | 0.285511 | 0.000261727 | 0.0163751
1533402 | Level 2 | 0.63394 | 0.000261727 | 0.0363588
1533799 | Level 2 | 0.217168 | 0.000261727 | 0.0124554
1534643 | Level 2 | 1.65847 | 0.000261727 | 0.0951193
1534788 | Level 2 | 0.973807 | 0.000261717 | 0.0558514
1534975 | Level 2 | 1.40172 | 0.000261727 | 0.0803936
1535875 | Level 2 | 1.11439 | 0.000445281 | 0.0833666
1535876 | Level 2 | 0.0318056 | 0.000445265 | 0.00237935
1535879 | Level 2 | 1.23982 | 0.000445281 | 0.0927499
1535881 | Level 2 | 5.31792 | 0.000445281 | 0.397829
1535894 | Level 2 | 0.807763 | 0.000261727 | 0.0463282
1535903 | Level 2 | 0.00269577 | 0.000445281 | 0.000201668
1535904 | Level 2 | 0.0179324 | 0.000445281 | 0.00134151
1535907 | Level 2 | 0.00269577 | 0.000445281 | 0.000201668
1535910 | Level 2 | 2.18222 | 0.000445281 | 0.16325
1535938 | Level 2 | 2.01683 | 0.000261727 | 0.115673
1535991 | Level 2 | 0.22955 | 0.000261727 | 0.0131655
1535992 | Level 2 | 1.31683 | 0.000261727 | 0.0755251
1536163 | Level 2 | 0.104631 | 0.000445281 | 0.00782737
1536164 | Level 2 | 2.09253 | 0.000445281 | 0.156541
1536356 | Level 2 | 0.237124 | 0.000445281 | 0.0177391
1537543 | Level 2 | 0.2426 | 0.000261727 | 0.013914
1538069 | Level 2 | 0.0101622 | 0.000261727 | 0.000582842
1538152 | Level 2 | 0.71197 | 0.000261727 | 0.0408341
1538324 | Level 2 | 0.00450539 | 0.000261727 | 0.000258401
1538362 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1538365 | Level 2 | 0.0234188 | 0.000261727 | 0.00134315
1538368 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1538401 | Level 2 | 0.514313 | 0.000261727 | 0.0294978
1538544 | Level 2 | 0.147059 | 0.000261727 | 0.0084344
1538711 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1538714 | Level 2 | 0.0234192 | 0.000261727 | 0.00134318
1538717 | Level 2 | 0.0101622 | 0.000261727 | 0.000582842
1538816 | Level 2 | 2.11844 | 0.000261727 | 0.1215
1540283 | Level 2 | 1.11439 | 0.000445281 | 0.0833666
1540284 | Level 2 | 0.0268056 | 0.000445281 | 0.0020053
1540287 | Level 2 | 1.23982 | 0.000445265 | 0.0927499
1540289 | Level 2 | 6.593 | 0.000445281 | 0.493217
1540290 | Level 2 | 0.2055 | 0.000445281 | 0.0153733
1540291 | Level 2 | 0.2055 | 0.000445281 | 0.0153733
1540292 | Level 2 | 0.114239 | 0.000445281 | 0.0085461
1540293 | Level 2 | 2.526 | 0.000445281 | 0.188968
1540295 | Level 2 | 2.57258 | 0.000261717 | 0.147547
1540301 | Level 2 | 2.40585 | 0.000261727 | 0.137984
1540302 | Level 2 | 0.424815 | 0.000261717 | 0.0243647
1540311 | Level 2 | 0.00269577 | 0.000445281 | 0.000201668
1540312 | Level 2 | 0.0179324 | 0.000445281 | 0.00134151
1540315 | Level 2 | 0.00269577 | 0.000445281 | 0.000201668
1540318 | Level 2 | 2.23222 | 0.000445281 | 0.16699
1540327 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1540330 | Level 2 | 0.2 | 0.000261727 | 0.0114707
1540333 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1540336 | Level 2 | 0.017729 | 0.000261727 | 0.00101682
1540339 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1540340 | Level 2 | 0.0179324 | 0.000261727 | 0.00102849
1540343 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1540346 | Level 2 | 0.291829 | 0.000261717 | 0.0167375
1540420 | Level 2 | 0.22955 | 0.000261727 | 0.0131655
1540421 | Level 2 | 1.34711 | 0.000261727 | 0.0772618
1540608 | Level 2 | 1.11439 | 0.000445281 | 0.0833666
1540609 | Level 2 | 0.0318056 | 0.000445281 | 0.00237935
1540612 | Level 2 | 1.23982 | 0.000445281 | 0.0927499
1540613 | Level 2 | 6.598 | 0.000445281 | 0.493591
1540614 | Level 2 | 0.2055 | 0.000445281 | 0.0153733
1540615 | Level 2 | 0.2055 | 0.000445281 | 0.0153733
1540616 | Level 2 | 0.11424 | 0.000445281 | 0.00854617
1540617 | Level 2 | 0.085021 | 0.000445281 | 0.00636035
1540618 | Level 2 | 2.5677 | 0.000261727 | 0.147267
1540621 | Level 2 | 2.40586 | 0.000261727 | 0.137985
1540622 | Level 2 | 0.424815 | 0.000261717 | 0.0243647
1540627 | Level 2 | 0.00269577 | 0.000445281 | 0.000201668
1540628 | Level 2 | 0.0179324 | 0.000445281 | 0.00134151
1540631 | Level 2 | 0.00269577 | 0.000445281 | 0.000201668
1540634 | Level 2 | 2.23222 | 0.000445281 | 0.16699
1540643 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1540646 | Level 2 | 0.22 | 0.000261727 | 0.0126178
1540649 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1540652 | Level 2 | 0.017729 | 0.000261727 | 0.00101682
1540655 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1540656 | Level 2 | 0.0179324 | 0.000261727 | 0.00102849
1540659 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1540662 | Level 2 | 0.291829 | 0.000261717 | 0.0167375
1540716 | Level 2 | 0.22955 | 0.000261727 | 0.0131655
