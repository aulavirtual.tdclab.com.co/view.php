Properties of the parts of a building model (IFC4), part 6 of 18

# IfcCableCarrierSegment: Conduit with Fittings:PVC (4616)
Name (Conduit with Fittings:PVC:...) | In | Length (m) | CrossSectionArea (m2) | OuterSurfaceArea (m2)
3031741 | Level 4 | 0.0234188 | 0.000261727 | 0.00134315
3031744 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031747 | Level 4 | 0.14887 | 0.000261727 | 0.00853825
3031752 | Level 4 | 1.75852 | 0.000261727 | 0.100858
3031756 | Level 4 | 0.286521 | 0.000261727 | 0.0164331
3031757 | Level 4 | 0.6963 | 0.000261727 | 0.0399354
3031763 | Level 4 | 1.11439 | 0.000445281 | 0.0833666
3031764 | Level 4 | 0.00675666 | 0.000445281 | 0.00050546
3031765 | Level 4 | 1.23982 | 0.000445281 | 0.0927499
3031766 | Level 4 | 6.573 | 0.000445281 | 0.491721
3031767 | Level 4 | 0.1985 | 0.000445265 | 0.0148496
3031768 | Level 4 | 0.2055 | 0.000445281 | 0.0153733
3031769 | Level 4 | 0.599014 | 0.000445281 | 0.0448118
3031770 | Level 4 | 3.25912 | 0.000445281 | 0.243812
3031771 | Level 4 | 1.9333 | 0.000261727 | 0.110882
3031772 | Level 4 | 0.424815 | 0.000261727 | 0.0243647
3031775 | Level 4 | 0.00269577 | 0.000445281 | 0.000201668
3031776 | Level 4 | 0.0179324 | 0.000445281 | 0.00134151
3031779 | Level 4 | 0.00269577 | 0.000445281 | 0.000201668
3031782 | Level 4 | 2.23222 | 0.000445281 | 0.16699
3031791 | Level 4 | 0.0115765 | 0.000261727 | 0.000663952
3031792 | Level 4 | 0.2 | 0.000261727 | 0.0114707
3031795 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031798 | Level 4 | 0.017729 | 0.000261727 | 0.00101682
3031801 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031802 | Level 4 | 0.0179324 | 0.000261727 | 0.00102849
3031805 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031808 | Level 4 | 0.291829 | 0.000261727 | 0.0167375
3031818 | Level 4 | 0.241091 | 0.000261727 | 0.0138274
3031819 | Level 4 | 1.35873 | 0.000261727 | 0.0779281
3031830 | Level 4 | 0.0387593 | 0.000261727 | 0.00222299
3031831 | Level 4 | 0.947858 | 0.000261727 | 0.0543631
3031833 | Level 4 | 0.0509781 | 0.000261727 | 0.00292378
3031834 | Level 4 | 0.0996307 | 0.000261727 | 0.00571419
3031837 | Level 4 | 0.33634 | 0.000261727 | 0.0192903
3031840 | Level 4 | 0.0996307 | 0.000261727 | 0.00571419
3031845 | Level 4 | 0.444809 | 0.000261727 | 0.0255115
3031847 | Level 4 | 0.0387586 | 0.000261727 | 0.00222295
3031848 | Level 4 | 0.947857 | 0.000261727 | 0.0543631
3031850 | Level 4 | 0.0509781 | 0.000261727 | 0.00292378
3031851 | Level 4 | 0.0996307 | 0.000261727 | 0.00571419
3031854 | Level 4 | 0.33634 | 0.000261727 | 0.0192903
3031857 | Level 4 | 0.0996307 | 0.000261727 | 0.00571419
3031862 | Level 4 | 0.444809 | 0.000261727 | 0.0255115
3031865 | Level 4 | 0.0387586 | 0.000261727 | 0.00222295
3031866 | Level 4 | 0.947857 | 0.000261727 | 0.0543631
3031867 | Level 4 | 0.0509781 | 0.000261727 | 0.00292378
3031868 | Level 4 | 0.0996307 | 0.000261727 | 0.00571419
3031871 | Level 4 | 0.33634 | 0.000261727 | 0.0192903
3031874 | Level 4 | 0.0996307 | 0.000261727 | 0.00571419
3031879 | Level 4 | 0.444809 | 0.000261727 | 0.0255115
3031881 | Level 4 | 0.0387593 | 0.000261727 | 0.00222299
3031882 | Level 4 | 0.947858 | 0.000261727 | 0.0543631
3031884 | Level 4 | 0.0509781 | 0.000261727 | 0.00292378
3031885 | Level 4 | 0.0996307 | 0.000261727 | 0.00571419
3031888 | Level 4 | 0.33634 | 0.000261727 | 0.0192903
3031891 | Level 4 | 0.0996307 | 0.000261727 | 0.00571419
3031896 | Level 4 | 0.444809 | 0.000261727 | 0.0255115
3031899 | Level 4 | 0.464617 | 0.000261727 | 0.0266475
3031902 | Level 4 | 0.502215 | 0.000261727 | 0.0288039
3031905 | Level 4 | 0.492204 | 0.000261727 | 0.0282297
3031908 | Level 4 | 0.502201 | 0.000261727 | 0.0288031
3031918 | Level 4 | 0.0118369 | 0.000261727 | 0.000678892
3031919 | Level 4 | 2.04169 | 0.000261727 | 0.117099
3031928 | Level 4 | 0.0119369 | 0.000261727 | 0.000684623
3031935 | Level 4 | 0.706826 | 0.000261727 | 0.0405391
3031938 | Level 4 | 0.743669 | 0.000261727 | 0.0426522
3031939 | Level 4 | 0.0119369 | 0.000261727 | 0.000684623
3031946 | Level 4 | 0.767057 | 0.000261727 | 0.0439936
3031951 | Level 4 | 0.00783803 | 0.000261727 | 0.00044954
3031952 | Level 4 | 0.250638 | 0.000261727 | 0.014375
3031957 | Level 4 | 0.0130309 | 0.000261727 | 0.000747368
3031960 | Level 4 | 0.0111381 | 0.000261727 | 0.000638809
3031961 | Level 4 | 0.631374 | 0.000261727 | 0.0362116
3031984 | Level 4 | 0.0303379 | 0.000261727 | 0.00173999
3031989 | Level 4 | 0.636683 | 0.000261727 | 0.0365161
3031990 | Level 4 | 0.030338 | 0.000261727 | 0.00174
3031997 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031998 | Level 4 | 0.125 | 0.000261727 | 0.00716921
3032001 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3032004 | Level 4 | 0.0399794 | 0.000261727 | 0.00229297
3032013 | Level 4 | 0.952057 | 0.000261727 | 0.054604
3032020 | Level 4 | 1.59457 | 0.000261727 | 0.0914544
3032025 | Level 4 | 0.188638 | 0.000261727 | 0.0108191
3032028 | Level 4 | 0.360934 | 0.000261727 | 0.0207009
3032031 | Level 4 | 0.0228375 | 0.000261717 | 0.00130982
3032034 | Level 4 | 2.04172 | 0.000261727 | 0.1171
3032043 | Level 4 | 0.0129394 | 0.000261727 | 0.000742123
3032044 | Level 4 | 0.743602 | 0.000261727 | 0.0426483
3032053 | Level 4 | 0.0129353 | 0.000261717 | 0.000741885
3032060 | Level 4 | 0.767057 | 0.000261727 | 0.0439936
3032065 | Level 4 | 0.0128395 | 0.000261727 | 0.000736393
3032068 | Level 4 | 0.048 | 0.000261727 | 0.00275298
3032071 | Level 4 | 0.755503 | 0.000261727 | 0.0433309
3032072 | Level 4 | 0.80457 | 0.000261727 | 0.0461451
3032077 | Level 4 | 0.253138 | 0.000261727 | 0.0145184
3032084 | Level 4 | 0.0130309 | 0.000261727 | 0.000747368
3032097 | Level 4 | 0.0261415 | 0.000261727 | 0.00149931
3032098 | Level 4 | 0.631373 | 0.000261727 | 0.0362116
3032107 | Level 4 | 0.254571 | 0.000261727 | 0.0146006
3032108 | Level 4 | 0.21706 | 0.000261727 | 0.0124492
3032109 | Level 4 | 0.0303402 | 0.000261727 | 0.00174012
3032110 | Level 4 | 0.636683 | 0.000261727 | 0.0365161
3032111 | Level 4 | 0.0303369 | 0.000261727 | 0.00173993
3032112 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3032113 | Level 4 | 0.125 | 0.000261727 | 0.00716921
3032116 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3032119 | Level 4 | 0.0399794 | 0.000261727 | 0.00229297
3032140 | Level 4 | 0.00788792 | 0.000261727 | 0.000452401
3032141 | Level 4 | 0.193138 | 0.000261727 | 0.0110772
3032150 | Level 4 | 1.06711 | 0.000261727 | 0.0612025
3032151 | Level 4 | 1.59457 | 0.000261727 | 0.0914544
3032154 | Level 4 | 1.04707 | 0.000261727 | 0.0600531
3032155 | Level 4 | 1.03611 | 0.000261727 | 0.0594246
3032156 | Level 4 | 0.27545 | 0.000261727 | 0.0157981
3032157 | Level 4 | 3.2319 | 0.000261727 | 0.185361
3032162 | Level 4 | 0.0168252 | 0.000261727 | 0.000964988
3032163 | Level 4 | 2.04171 | 0.000261727 | 0.1171
3032176 | Level 4 | 0.699326 | 0.000261727 | 0.0401089
3032177 | Level 4 | 0.743652 | 0.000261727 | 0.0426512
3032182 | Level 4 | 0.0169369 | 0.000261727 | 0.000971391
3032185 | Level 4 | 0.804569 | 0.000261727 | 0.046145
3032186 | Level 4 | 0.804569 | 0.000261717 | 0.046145
3032191 | Level 4 | 0.767057 | 0.000261727 | 0.0439936
3032198 | Level 4 | 0.00783877 | 0.000261727 | 0.000449583
3032207 | Level 4 | 0.048 | 0.000261727 | 0.00275298
3032214 | Level 4 | 0.0205541 | 0.000261727 | 0.00117885
3032227 | Level 4 | 0.0161354 | 0.000261727 | 0.000925423
3032234 | Level 4 | 0.254571 | 0.000261727 | 0.0146006
3032235 | Level 4 | 0.0303402 | 0.000261727 | 0.00174012
3032236 | Level 4 | 0.636683 | 0.000261727 | 0.0365161
3032237 | Level 4 | 0.0301287 | 0.000261727 | 0.00172799
3032238 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3032239 | Level 4 | 0.125 | 0.000261727 | 0.00716921
3032242 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3032245 | Level 4 | 0.0399794 | 0.000261727 | 0.00229297
3032262 | Level 4 | 0.204391 | 0.000261727 | 0.0117226
3032269 | Level 4 | 1.59457 | 0.000261727 | 0.0914544
3032270 | Level 4 | 0.196942 | 0.000261727 | 0.0112954
3032277 | Level 4 | 0.0183334 | 0.000261727 | 0.00105149
3032278 | Level 4 | 2.04219 | 0.000261727 | 0.117127
3032291 | Level 4 | 0.684326 | 0.000261727 | 0.0392486
3032294 | Level 4 | 0.743669 | 0.000261727 | 0.0426522
3032301 | Level 4 | 0.0229379 | 0.000261727 | 0.00131557
3032308 | Level 4 | 0.021137 | 0.000261727 | 0.00121229
3032320 | Level 4 | 0.00803087 | 0.000261727 | 0.0004606
3032339 | Level 4 | 0.048 | 0.000261727 | 0.00275298
3032340 | Level 4 | 0.00836907 | 0.000261727 | 0.000479997
3032347 | Level 4 | 0.767057 | 0.000261727 | 0.0439936
3032352 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3032353 | Level 4 | 0.0303379 | 0.000261727 | 0.00173999
3032354 | Level 4 | 0.636683 | 0.000261727 | 0.0365161
3032355 | Level 4 | 0.0301411 | 0.000261727 | 0.0017287
3032356 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3032357 | Level 4 | 0.125 | 0.000261727 | 0.00716921
3032360 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3032363 | Level 4 | 0.0399794 | 0.000261727 | 0.00229297
3032378 | Level 4 | 0.188638 | 0.000261727 | 0.0108191
3032387 | Level 4 | 1.06711 | 0.000261727 | 0.0612025
3032388 | Level 4 | 1.59457 | 0.000261727 | 0.0914544
3032393 | Level 4 | 0.285509 | 0.000261727 | 0.016375
3032396 | Level 4 | 1.04706 | 0.000261727 | 0.0600526
3032399 | Level 4 | 2.84962 | 0.000261727 | 0.163436
3032400 | Level 4 | 2.87235 | 0.000261727 | 0.16474
3032401 | Level 4 | 2.84568 | 0.000445281 | 0.212883
3032402 | Level 4 | 0.258057 | 0.000261727 | 0.0148005
3032403 | Level 4 | 0.258057 | 0.000261727 | 0.0148005
3032404 | Level 4 | 0.25285 | 0.000445281 | 0.0189155
3032405 | Level 4 | 0.269062 | 0.000445281 | 0.0201283
3032406 | Level 4 | 0.244596 | 0.000261727 | 0.0140285
3032407 | Level 4 | 0.214512 | 0.000261727 | 0.0123031
3032408 | Level 4 | 0.0255161 | 0.000445281 | 0.00190884
3032409 | Level 4 | 0.273143 | 0.000445281 | 0.0204336
3032412 | Level 4 | 0.0255161 | 0.000445281 | 0.00190884
3032415 | Level 4 | 0.0531472 | 0.000445281 | 0.0039759
3032420 | Level 4 | 0.05832 | 0.000261727 | 0.00334487
3032421 | Level 4 | 0.0277886 | 0.000261727 | 0.00159378
3032422 | Level 4 | 0.0751356 | 0.000261727 | 0.0043093
3032425 | Level 4 | 0.0277886 | 0.000261727 | 0.00159378
3032432 | Level 4 | 0.0115765 | 0.000261727 | 0.000663952
3032433 | Level 4 | 3.3027 | 0.000261727 | 0.189422
3032434 | Level 4 | 0.0125953 | 0.000445281 | 0.000942241
3032435 | Level 4 | 0.0277886 | 0.000261727 | 0.00159378
3032436 | Level 4 | 0.195169 | 0.000261727 | 0.0111936
3032445 | Level 4 | 0.0115765 | 0.000261727 | 0.000663952
3032446 | Level 4 | 0.0277886 | 0.000261727 | 0.00159378
3032447 | Level 4 | 0.195169 | 0.000261727 | 0.0111936
3032452 | Level 4 | 1.15372 | 0.000261727 | 0.0661699
3032463 | Level 4 | 0.0288274 | 0.000445281 | 0.00215656
3032464 | Level 4 | 0.192491 | 0.000445281 | 0.0144001
3032483 | Level 4 | 0.0315074 | 0.000261727 | 0.00180706
3032484 | Level 4 | 0.695638 | 0.000261727 | 0.0398974
3032487 | Level 4 | 0.356826 | 0.000261727 | 0.0204653
3032492 | Level 4 | 0.0314726 | 0.000261727 | 0.00180507
3032493 | Level 4 | 0.695638 | 0.000261727 | 0.0398974
3032494 | Level 4 | 0.356923 | 0.000261727 | 0.0204708
3032503 | Level 4 | 0.0316382 | 0.000261727 | 0.00181457
3032504 | Level 4 | 0.695638 | 0.000261727 | 0.0398974
3032505 | Level 4 | 0.356495 | 0.000261727 | 0.0204463
3032508 | Level 4 | 0.0315588 | 0.000261727 | 0.00181001
3032509 | Level 4 | 0.695638 | 0.000261727 | 0.0398974
3032510 | Level 4 | 0.356436 | 0.000261727 | 0.0204429
3032525 | Level 4 | 0.279532 | 0.000261727 | 0.0160322
3032526 | Level 4 | 0.0475876 | 0.000261727 | 0.00272933
3032527 | Level 4 | 0.0363541 | 0.000261727 | 0.00208504
3032536 | Level 4 | 0.250299 | 0.000261727 | 0.0143556
3032537 | Level 4 | 0.0475876 | 0.000261727 | 0.00272933
3032538 | Level 4 | 0.0771443 | 0.000261727 | 0.00442451
3032547 | Level 4 | 0.269295 | 0.000261727 | 0.0154451
3032548 | Level 4 | 0.0475876 | 0.000261727 | 0.00272933
3032549 | Level 4 | 0.0581536 | 0.000261727 | 0.00333532
3032556 | Level 4 | 0.15765 | 0.000261727 | 0.00904183
3032557 | Level 4 | 0.0490018 | 0.000261727 | 0.00281044
3032558 | Level 4 | 0.081437 | 0.000261727 | 0.00467071
3032565 | Level 4 | 0.817376 | 0.000261717 | 0.0468795
3032566 | Level 4 | 0.0045054 | 0.000261727 | 0.000258402
3032567 | Level 4 | 0.455819 | 0.000261727 | 0.0261429
3032576 | Level 4 | 0.221123 | 0.000261727 | 0.0126822
3032577 | Level 4 | 0.0242115 | 0.000261727 | 0.00138862
3032578 | Level 4 | 0.330327 | 0.000261727 | 0.0189455
3032581 | Level 4 | 0.024215 | 0.000261727 | 0.00138882
3032584 | Level 4 | 0.680212 | 0.000261727 | 0.0390127
3032593 | Level 4 | 0.514375 | 0.000261717 | 0.0295013
3032594 | Level 4 | 0.0419308 | 0.000261727 | 0.00240488
3032595 | Level 4 | 0.184076 | 0.000261727 | 0.0105574
3032598 | Level 4 | 0.0724778 | 0.000261727 | 0.00415687
3032601 | Level 4 | 0.556051 | 0.000261727 | 0.0318916
3032610 | Level 4 | 0.538454 | 0.000261727 | 0.0308823
3032611 | Level 4 | 0.00450551 | 0.000261727 | 0.000258408
3032612 | Level 4 | 0.0825002 | 0.000261727 | 0.00473169
3032615 | Level 4 | 0.0327894 | 0.000261727 | 0.0018806
3032618 | Level 4 | 0.602073 | 0.000261727 | 0.0345311
3032627 | Level 4 | 0.737436 | 0.000261727 | 0.0422947
3032628 | Level 4 | 0.0101622 | 0.000261727 | 0.000582842
3032629 | Level 4 | 0.05 | 0.000261727 | 0.00286769
3032632 | Level 4 | 0.0101622 | 0.000261727 | 0.000582842
3032635 | Level 4 | 0.264814 | 0.000261727 | 0.0151881
3032646 | Level 4 | 0.737436 | 0.000261717 | 0.0422947
3032647 | Level 4 | 0.0101622 | 0.000261727 | 0.000582842
3032648 | Level 4 | 0.05 | 0.000261727 | 0.00286769
3032651 | Level 4 | 0.0101622 | 0.000261727 | 0.000582842
3032654 | Level 4 | 0.264814 | 0.000261727 | 0.0151881
3032663 | Level 4 | 0.253257 | 0.000261727 | 0.0145253
3032664 | Level 4 | 0.0101622 | 0.000261727 | 0.000582842
3032665 | Level 4 | 0.05 | 0.000261727 | 0.00286769
3032668 | Level 4 | 0.0101622 | 0.000261727 | 0.000582842
3032671 | Level 4 | 0.737436 | 0.000261727 | 0.0422947
3032680 | Level 4 | 0.0219966 | 0.000261727 | 0.00126159
3032681 | Level 4 | 1.07863 | 0.000261727 | 0.0618632
3032684 | Level 4 | 0.836436 | 0.000261727 | 0.0479727
3032687 | Level 4 | 0.163814 | 0.000261727 | 0.00939536
3032688 | Level 4 | 0.0115765 | 0.000261727 | 0.000663952
3032689 | Level 4 | 0.05 | 0.000261727 | 0.00286769
3032692 | Level 4 | 0.0115765 | 0.000261727 | 0.000663952
3032703 | Level 4 | 0.685939 | 0.000261727 | 0.0393411
3032704 | Level 4 | 0.00450199 | 0.000261727 | 0.000258206
3032705 | Level 4 | 0.0499976 | 0.000261727 | 0.00286755
3032708 | Level 4 | 0.00450368 | 0.000261727 | 0.000258303
3032711 | Level 4 | 0.0573411 | 0.000261727 | 0.00328872
3032718 | Level 4 | 0.686053 | 0.000261727 | 0.0393477
3032719 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3032720 | Level 4 | 0.05 | 0.000261727 | 0.00286769
3032723 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3032726 | Level 4 | 0.0455759 | 0.000261717 | 0.00261395
3032735 | Level 4 | 0.0480437 | 0.000261727 | 0.00275549
3032736 | Level 4 | 0.00450392 | 0.000261727 | 0.000258316
3032737 | Level 4 | 0.0499979 | 0.000261727 | 0.00286757
3032740 | Level 4 | 0.0045024 | 0.000261727 | 0.000258229
3032743 | Level 4 | 0.675021 | 0.000261727 | 0.038715
3032752 | Level 4 | 0.0518201 | 0.000261727 | 0.00297207
3032753 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3032754 | Level 4 | 0.05 | 0.000261727 | 0.00286769
3032757 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3032760 | Level 4 | 0.68655 | 0.000261727 | 0.0393762
3032769 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032770 | Level 4 | 0.175 | 0.000261727 | 0.0100369
3032773 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032776 | Level 4 | 0.0611205 | 0.000261727 | 0.00350548
3032777 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032778 | Level 4 | 0.175 | 0.000261727 | 0.0100369
3032781 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032784 | Level 4 | 0.0611205 | 0.000261727 | 0.00350548
3032797 | Level 4 | 0.0483648 | 0.000261727 | 0.0027739
3032798 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032799 | Level 4 | 0.14625 | 0.000261727 | 0.00838798
3032802 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032805 | Level 4 | 0.757407 | 0.000261727 | 0.0434401
3032806 | Level 4 | 0.0483648 | 0.000261727 | 0.0027739
3032807 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032808 | Level 4 | 0.14625 | 0.000261727 | 0.00838798
3032811 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032814 | Level 4 | 1.17889 | 0.000261727 | 0.0676139
3032831 | Level 4 | 1.17815 | 0.000261727 | 0.0675715
3032832 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032833 | Level 4 | 0.145 | 0.000261727 | 0.00831629
3032836 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032839 | Level 4 | 0.061911 | 0.000261727 | 0.00355082
3032840 | Level 4 | 0.756668 | 0.000261727 | 0.0433977
3032841 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032842 | Level 4 | 0.145 | 0.000261727 | 0.00831629
3032845 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032848 | Level 4 | 0.061911 | 0.000261727 | 0.00355082
3032863 | Level 4 | 0.0433648 | 0.000261727 | 0.00248713
3032864 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032865 | Level 4 | 0.1675 | 0.000261727 | 0.00960674
3032868 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032871 | Level 4 | 0.741157 | 0.000261727 | 0.0425081
3032872 | Level 4 | 0.0433648 | 0.000261727 | 0.00248713
3032873 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032874 | Level 4 | 0.1675 | 0.000261727 | 0.00960674
3032877 | Level 4 | 0.0327897 | 0.000261727 | 0.00188061
3032880 | Level 4 | 1.16264 | 0.000261727 | 0.0666819
3032898 | Level 4 | 0.774569 | 0.000261727 | 0.0444244
3032903 | Level 4 | 0.0752445 | 0.000261727 | 0.00431555
3032904 | Level 4 | 1.36611 | 0.000261727 | 0.0783517
3032907 | Level 4 | 1.13386 | 0.000261727 | 0.065031
3032911 | Level 4 | 0.774569 | 0.000261727 | 0.0444244
3032916 | Level 4 | 0.075193 | 0.000261727 | 0.0043126
3032917 | Level 4 | 1.36536 | 0.000261727 | 0.0783087
3032920 | Level 4 | 0.754569 | 0.000261727 | 0.0432773
3032925 | Level 4 | 0.073057 | 0.000261727 | 0.00419009
3032926 | Level 4 | 1.36611 | 0.000261727 | 0.0783517
3032929 | Level 4 | 1.13386 | 0.000261727 | 0.065031
3032933 | Level 4 | 0.774569 | 0.000261727 | 0.0444244
3032940 | Level 4 | 0.0756929 | 0.000261727 | 0.00434127
3032941 | Level 4 | 1.36531 | 0.000261727 | 0.0783058
3032944 | Level 4 | 1.13386 | 0.000261727 | 0.065031
3032947 | Level 4 | 1.13386 | 0.000261727 | 0.065031
3033708 | Level 5 | 0.279115 | 0.000261727 | 0.0160083
3033709 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3033710 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3033711 | Level 5 | 0.0229341 | 0.000261727 | 0.00131535
3033712 | Level 5 | 1.15457 | 0.000261727 | 0.0662188
3033713 | Level 5 | 0.804569 | 0.000261727 | 0.046145
3033714 | Level 5 | 0.804569 | 0.000261727 | 0.046145
3033715 | Level 5 | 2.51533 | 0.000261717 | 0.144263
3033717 | Level 5 | 1.8555 | 0.000261727 | 0.10642
3033718 | Level 5 | 0.615816 | 0.000261727 | 0.0353193
3033720 | Level 5 | 0.998002 | 0.000261727 | 0.0572391
3033721 | Level 5 | 0.448 | 0.000261727 | 0.0256945
3033722 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3033723 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3033725 | Level 5 | 0.668585 | 0.000261727 | 0.0383458
3033726 | Level 5 | 1.51706 | 0.000261727 | 0.0870088
3033727 | Level 5 | 0.441527 | 0.000261727 | 0.0253232
3033729 | Level 5 | 1.048 | 0.000261727 | 0.0601068
3033730 | Level 5 | 0.1026 | 0.000261727 | 0.00588449
3033731 | Level 5 | 0.7926 | 0.000261727 | 0.0454585
3033732 | Level 5 | 0.767057 | 0.000261727 | 0.0439936
3033733 | Level 5 | 0.296722 | 0.000261727 | 0.0170181
3033734 | Level 5 | 0.0229379 | 0.000261727 | 0.00131557
3033735 | Level 5 | 0.0408 | 0.000261727 | 0.00234003
3033736 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3033737 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3033738 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3033739 | Level 5 | 0.631383 | 0.000261727 | 0.0362121
3033740 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3033741 | Level 5 | 0.0142587 | 0.000261727 | 0.000817789
3033746 | Level 5 | 0.804569 | 0.000261727 | 0.046145
3033747 | Level 5 | 0.767057 | 0.000261727 | 0.0439936
3033750 | Level 5 | 2.1564 | 0.000261727 | 0.123678
3033751 | Level 5 | 0.166402 | 0.000261727 | 0.00954375
3033754 | Level 5 | 0.17942 | 0.000261727 | 0.0102904
3033755 | Level 5 | 0.941555 | 0.000261727 | 0.0540017
3033756 | Level 5 | 2.69157 | 0.000261727 | 0.154372
3033757 | Level 5 | 1.3965 | 0.000261727 | 0.0800944
3033758 | Level 5 | 0.589 | 0.000261727 | 0.0337813
3033759 | Level 5 | 0.403493 | 0.000261717 | 0.0231418
3033760 | Level 5 | 0.012888 | 0.000261727 | 0.000739177
3033761 | Level 5 | 0.368727 | 0.000261727 | 0.0211479
3033762 | Level 5 | 0.0131379 | 0.000261727 | 0.000753508
3033763 | Level 5 | 1.11391 | 0.000261727 | 0.063887
3033766 | Level 5 | 0.324805 | 0.000261727 | 0.0186288
3033767 | Level 5 | 0.173109 | 0.000261727 | 0.00992845
3033768 | Level 5 | 0.0507798 | 0.000261727 | 0.00291241
3033769 | Level 5 | 1.8475 | 0.000261727 | 0.105961
3033771 | Level 5 | 1.548 | 0.000261727 | 0.0887836
3033773 | Level 5 | 0.4 | 0.000261727 | 0.0229415
3033774 | Level 5 | 0.391107 | 0.000261727 | 0.0224314
3033775 | Level 5 | 0.241107 | 0.000261727 | 0.0138284
3033776 | Level 5 | 0.767057 | 0.000261727 | 0.0439936
3033777 | Level 5 | 3.49886 | 0.000261727 | 0.200672
3033778 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3033781 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3033783 | Level 5 | 1.95457 | 0.000261727 | 0.112102
3033784 | Level 5 | 1.9055 | 0.000261727 | 0.109288
3033785 | Level 5 | 0.6355 | 0.000261727 | 0.0364483
3033786 | Level 5 | 1.09862 | 0.000261717 | 0.0630099
3033787 | Level 5 | 0.0174379 | 0.000261727 | 0.00100013
3033788 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3033789 | Level 5 | 0.171257 | 0.000261727 | 0.00982222
3033794 | Level 5 | 0.0229379 | 0.000261727 | 0.00131557
3033795 | Level 5 | 0.273138 | 0.000261727 | 0.0156655
3033798 | Level 5 | 0.201138 | 0.000261727 | 0.011536
3033799 | Level 5 | 0.657257 | 0.000261727 | 0.0376961
3033802 | Level 5 | 0.097445 | 0.000261727 | 0.00558883
3033803 | Level 5 | 0.0843352 | 0.000261727 | 0.00483694
3033804 | Level 5 | 0.727458 | 0.000261727 | 0.0417224
3033805 | Level 5 | 0.182857 | 0.000261727 | 0.0104875
3033808 | Level 5 | 1.14894 | 0.000261727 | 0.0658962
3033810 | Level 5 | 0.158503 | 0.000261727 | 0.00909073
3033813 | Level 5 | 0.202183 | 0.000261727 | 0.011596
3033814 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3033815 | Level 5 | 0.0875 | 0.000261727 | 0.00501845
3033818 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3033821 | Level 5 | 0.563915 | 0.000261727 | 0.0323426
3033828 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3033829 | Level 5 | 0.0234188 | 0.000261727 | 0.00134315
3033832 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3033835 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3033836 | Level 5 | 0.0234188 | 0.000261727 | 0.00134315
3033839 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3033842 | Level 5 | 0.14887 | 0.000261727 | 0.00853825
3033847 | Level 5 | 1.75852 | 0.000261727 | 0.100858
3033876 | Level 5 | 0.278619 | 0.000261727 | 0.0159798
3033877 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3033878 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3033879 | Level 5 | 0.0164369 | 0.000261717 | 0.000942715
3033880 | Level 5 | 1.15457 | 0.000261727 | 0.0662188
3033881 | Level 5 | 0.804569 | 0.000261727 | 0.046145
3033882 | Level 5 | 0.804569 | 0.000261727 | 0.046145
3033883 | Level 5 | 2.52633 | 0.000261727 | 0.144894
3033885 | Level 5 | 1.8555 | 0.000261727 | 0.10642
3033886 | Level 5 | 0.615816 | 0.000261727 | 0.0353193
3033888 | Level 5 | 0.998002 | 0.000261727 | 0.0572391
3033889 | Level 5 | 0.448 | 0.000261727 | 0.0256945
3033890 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3033891 | Level 5 | 0.2426 | 0.000261727 | 0.013914
3033893 | Level 5 | 0.66863 | 0.000261727 | 0.0383484
3033894 | Level 5 | 1.50553 | 0.000261727 | 0.0863477
3033895 | Level 5 | 0.42997 | 0.000261717 | 0.0246603
3033897 | Level 5 | 0.998002 | 0.000261727 | 0.0572391
3033898 | Level 5 | 0.048 | 0.000261727 | 0.00275298
3033899 | Level 5 | 0.1026 | 0.000261727 | 0.00588449
3033900 | Level 5 | 0.804569 | 0.000261717 | 0.046145
3033901 | Level 5 | 0.7555 | 0.000261727 | 0.0433307
3033902 | Level 5 | 0.296722 | 0.000261727 | 0.0170181
3033903 | Level 5 | 0.0408 | 0.000261727 | 0.00234003
3033904 | Level 5 | 0.254619 | 0.000261727 | 0.0146033
3033905 | Level 5 | 0.2055 | 0.000261727 | 0.0117862
3033906 | Level 5 | 0.2055 | 0.000261727 | 0.0117862
3033907 | Level 5 | 0.0142587 | 0.000261727 | 0.000817789
3033911 | Level 5 | 0.824569 | 0.000261727 | 0.0472921
3033912 | Level 5 | 0.7555 | 0.000261727 | 0.0433307
3033915 | Level 5 | 2.1564 | 0.000261727 | 0.123678
3033916 | Level 5 | 0.216402 | 0.000261727 | 0.0124114
3033919 | Level 5 | 0.679625 | 0.000261717 | 0.038979
3033920 | Level 5 | 0.941552 | 0.000261727 | 0.0540015
3033921 | Level 5 | 2.74157 | 0.000261717 | 0.157239
3033922 | Level 5 | 1.3965 | 0.000261727 | 0.0800944
3033923 | Level 5 | 0.589 | 0.000261727 | 0.0337813
3033924 | Level 5 | 0.405071 | 0.000261727 | 0.0232323
3033925 | Level 5 | 0.00571991 | 0.000261727 | 0.000328058
3033926 | Level 5 | 0.0175129 | 0.000261727 | 0.00100443
3033929 | Level 5 | 1.10235 | 0.000261727 | 0.0632241
3033932 | Level 5 | 0.443274 | 0.000261727 | 0.0254234
3033933 | Level 5 | 0.243454 | 0.000261727 | 0.013963
3033934 | Level 5 | 0.106348 | 0.000261727 | 0.00609945
3033935 | Level 5 | 1.8475 | 0.000261727 | 0.105961
3033939 | Level 5 | 0.4481 | 0.000261727 | 0.0257002
3033940 | Level 5 | 0.391107 | 0.000261727 | 0.0224314
3033941 | Level 5 | 0.32955 | 0.000261727 | 0.0189009
3033942 | Level 5 | 0.7555 | 0.000261727 | 0.0433307
3033943 | Level 5 | 3.4873 | 0.000261727 | 0.20001
3033944 | Level 5 | 0.2055 | 0.000261727 | 0.0117862
3033947 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3033948 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3033950 | Level 5 | 1.90457 | 0.000261727 | 0.109234
3033951 | Level 5 | 1.86706 | 0.000261727 | 0.107083
3033952 | Level 5 | 0.022438 | 0.000261727 | 0.0012869
3033953 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3033954 | Level 5 | 0.171257 | 0.000261727 | 0.00982222
3033957 | Level 5 | 0.0119369 | 0.000261727 | 0.000684623
3033958 | Level 5 | 0.188638 | 0.000261727 | 0.0108191
3033959 | Level 5 | 0.6457 | 0.000261727 | 0.0370333
3033964 | Level 5 | 0.0635071 | 0.000261717 | 0.00364236
3033965 | Level 5 | 0.0893379 | 0.000261727 | 0.00512386
3033968 | Level 5 | 0.182857 | 0.000261727 | 0.0104875
3033974 | Level 5 | 0.158503 | 0.000261727 | 0.00909073
3033977 | Level 5 | 0.190632 | 0.000261727 | 0.0109334
3033978 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3033979 | Level 5 | 0.05 | 0.000261727 | 0.00286769
3033982 | Level 5 | 0.00450539 | 0.000261727 | 0.000258401
3033985 | Level 5 | 0.112766 | 0.000261727 | 0.00646757
3033988 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3033989 | Level 5 | 0.0234188 | 0.000261727 | 0.00134315
3033992 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3033995 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3033996 | Level 5 | 0.0234188 | 0.000261727 | 0.00134315
3033999 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034002 | Level 5 | 0.136901 | 0.000261727 | 0.00785178
3034009 | Level 5 | 1.74696 | 0.000261727 | 0.100195
3034016 | Level 5 | 0.297059 | 0.000261727 | 0.0170374
3034017 | Level 5 | 0.645459 | 0.000261727 | 0.0370195
3034018 | Level 5 | 1.04706 | 0.000261727 | 0.0600526
3034041 | Level 5 | 0.278619 | 0.000261727 | 0.0159798
3034042 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3034043 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3034044 | Level 5 | 0.0214432 | 0.000261727 | 0.00122985
3034045 | Level 5 | 1.15457 | 0.000261727 | 0.0662188
3034046 | Level 5 | 2.52133 | 0.000261727 | 0.144607
3034048 | Level 5 | 1.8555 | 0.000261727 | 0.10642
3034049 | Level 5 | 0.615816 | 0.000261727 | 0.0353193
3034051 | Level 5 | 0.85 | 0.000261727 | 0.0487506
3034052 | Level 5 | 0.335 | 0.000261727 | 0.0192135
3034053 | Level 5 | 0.195569 | 0.000261727 | 0.0112166
3034054 | Level 5 | 0.205569 | 0.000261727 | 0.0117901
3034056 | Level 5 | 0.639628 | 0.000261727 | 0.036685
3034057 | Level 5 | 1.51185 | 0.000261727 | 0.0867102
3034058 | Level 5 | 0.441527 | 0.000261717 | 0.0253232
3034060 | Level 5 | 1.048 | 0.000261727 | 0.0601068
3034061 | Level 5 | 0.102605 | 0.000261727 | 0.00588477
3034062 | Level 5 | 0.805 | 0.000261727 | 0.0461697
3034063 | Level 5 | 0.767058 | 0.000261727 | 0.0439936
3034064 | Level 5 | 0.296722 | 0.000261727 | 0.0170181
3034065 | Level 5 | 0.0169364 | 0.000261717 | 0.000971367
3034066 | Level 5 | 0.0408049 | 0.000261722 | 0.00234031
3034067 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3034068 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3034069 | Level 5 | 0.631374 | 0.000261727 | 0.0362116
3034070 | Level 5 | 0.1465 | 0.000261727 | 0.00840232
3034071 | Level 5 | 1.06711 | 0.000261727 | 0.0612025
3034072 | Level 5 | 0.0142587 | 0.000261727 | 0.000817789
3034076 | Level 5 | 0.824569 | 0.000261727 | 0.0472921
3034077 | Level 5 | 0.767057 | 0.000261727 | 0.0439936
3034080 | Level 5 | 2.1564 | 0.000261727 | 0.123678
3034081 | Level 5 | 0.216402 | 0.000261727 | 0.0124114
3034084 | Level 5 | 0.71239 | 0.000261717 | 0.0408582
3034085 | Level 5 | 0.941552 | 0.000261727 | 0.0540015
3034086 | Level 5 | 2.74157 | 0.000261717 | 0.157239
3034087 | Level 5 | 1.40806 | 0.000261727 | 0.0807573
3034088 | Level 5 | 0.589 | 0.000261727 | 0.0337813
3034089 | Level 5 | 0.43414 | 0.000261727 | 0.0248995
3034090 | Level 5 | 0.0103879 | 0.000261727 | 0.000595785
3034091 | Level 5 | 0.365602 | 0.000261727 | 0.0209686
3034092 | Level 5 | 0.0338912 | 0.000261727 | 0.00194379
3034093 | Level 5 | 1.11391 | 0.000261727 | 0.063887
3034096 | Level 5 | 0.310436 | 0.000261727 | 0.0178046
3034097 | Level 5 | 0.187113 | 0.000261727 | 0.0107316
3034098 | Level 5 | 0.0523645 | 0.000261727 | 0.0030033
3034101 | Level 5 | 1.8475 | 0.000261727 | 0.105961
3034105 | Level 5 | 0.4481 | 0.000261727 | 0.0257002
3034106 | Level 5 | 0.391107 | 0.000261727 | 0.0224314
3034107 | Level 5 | 0.241107 | 0.000261727 | 0.0138284
3034108 | Level 5 | 0.767057 | 0.000261727 | 0.0439936
3034109 | Level 5 | 3.49886 | 0.000261727 | 0.200672
3034110 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3034113 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3034115 | Level 5 | 1.90457 | 0.000261727 | 0.109234
3034116 | Level 5 | 1.8555 | 0.000261727 | 0.10642
3034117 | Level 5 | 1.22362 | 0.000261727 | 0.0701791
3034118 | Level 5 | 0.0124377 | 0.000261727 | 0.000713349
3034119 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3034120 | Level 5 | 0.171257 | 0.000261727 | 0.00982222
3034125 | Level 5 | 0.0169369 | 0.000261727 | 0.000971391
3034126 | Level 5 | 0.258138 | 0.000261727 | 0.0148052
3034129 | Level 5 | 0.188638 | 0.000261727 | 0.0108191
3034132 | Level 5 | 0.657257 | 0.000261727 | 0.0376961
3034133 | Level 5 | 0.092445 | 0.000261717 | 0.00530206
3034136 | Level 5 | 0.0968611 | 0.000261727 | 0.00555534
3034137 | Level 5 | 0.182857 | 0.000261727 | 0.0104875
3034141 | Level 5 | 0.158503 | 0.000261727 | 0.00909073
3034144 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034145 | Level 5 | 0.085 | 0.000261727 | 0.00487506
3034148 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034151 | Level 5 | 0.0334442 | 0.000261727 | 0.00191815
3034158 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034159 | Level 5 | 0.0234188 | 0.000261727 | 0.00134315
3034162 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034165 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034166 | Level 5 | 0.0234188 | 0.000261727 | 0.00134315
3034169 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034172 | Level 5 | 0.14887 | 0.000261727 | 0.00853825
3034177 | Level 5 | 1.74696 | 0.000261727 | 0.100195
3034184 | Level 5 | 0.254567 | 0.000261727 | 0.0146003
3034185 | Level 5 | 1.548 | 0.000261727 | 0.0887836
3034186 | Level 5 | 0.645457 | 0.000261727 | 0.0370193
3034187 | Level 5 | 1.0355 | 0.000261727 | 0.0593897
3034188 | Level 5 | 0.2855 | 0.000261727 | 0.0163745
3034215 | Level 5 | 0.278619 | 0.000261727 | 0.0159798
3034216 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3034217 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3034218 | Level 5 | 0.027438 | 0.000261727 | 0.00157367
3034219 | Level 5 | 1.15457 | 0.000261717 | 0.0662188
3034220 | Level 5 | 0.804568 | 0.000261727 | 0.046145
3034221 | Level 5 | 0.804568 | 0.000261727 | 0.046145
3034222 | Level 5 | 2.56284 | 0.000261717 | 0.146988
3034224 | Level 5 | 1.8555 | 0.000261727 | 0.10642
3034225 | Level 5 | 0.615816 | 0.000261727 | 0.0353193
3034227 | Level 5 | 1.048 | 0.000261727 | 0.0601068
3034228 | Level 5 | 0.448 | 0.000261727 | 0.0256945
3034229 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3034230 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3034232 | Level 5 | 0.653897 | 0.000261727 | 0.0375034
3034233 | Level 5 | 1.51705 | 0.000261727 | 0.0870082
3034234 | Level 5 | 0.441527 | 0.000261717 | 0.0253232
3034236 | Level 5 | 0.998002 | 0.000261717 | 0.0572391
3034237 | Level 5 | 0.102603 | 0.000261727 | 0.00588469
3034238 | Level 5 | 0.0129369 | 0.000261717 | 0.000741977
3034239 | Level 5 | 0.0408183 | 0.000261727 | 0.00234108
3034240 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3034241 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3034242 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3034243 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3034244 | Level 5 | 0.0142642 | 0.000261727 | 0.000818107
3034248 | Level 5 | 0.824569 | 0.000261727 | 0.0472921
3034249 | Level 5 | 0.7555 | 0.000261727 | 0.0433307
3034252 | Level 5 | 2.1564 | 0.000261727 | 0.123678
3034253 | Level 5 | 0.216402 | 0.000261727 | 0.0124114
3034256 | Level 5 | 0.18442 | 0.000261727 | 0.0105772
3034257 | Level 5 | 0.941552 | 0.000261727 | 0.0540015
3034258 | Level 5 | 2.69157 | 0.000261727 | 0.154372
3034259 | Level 5 | 1.40806 | 0.000261727 | 0.0807573
3034260 | Level 5 | 0.589 | 0.000261727 | 0.0337813
3034261 | Level 5 | 0.429721 | 0.000261727 | 0.0246461
3034262 | Level 5 | 0.362602 | 0.000261727 | 0.0207966
3034263 | Level 5 | 0.0188879 | 0.000261727 | 0.00108329
3034266 | Level 5 | 1.10236 | 0.000261727 | 0.0632243
3034269 | Level 5 | 0.431477 | 0.000261727 | 0.0247468
3034270 | Level 5 | 0.243258 | 0.000261727 | 0.0139517
3034273 | Level 5 | 1.8475 | 0.000261727 | 0.105961
3034276 | Level 5 | 1.548 | 0.000261727 | 0.0887836
3034278 | Level 5 | 0.4481 | 0.000261727 | 0.0257002
3034279 | Level 5 | 0.391107 | 0.000261727 | 0.0224314
3034280 | Level 5 | 0.241107 | 0.000261727 | 0.0138284
3034281 | Level 5 | 0.7555 | 0.000261727 | 0.0433307
3034282 | Level 5 | 3.49886 | 0.000261727 | 0.200672
3034283 | Level 5 | 0.217057 | 0.000261727 | 0.012449
3034287 | Level 5 | 1.90457 | 0.000261727 | 0.109234
3034288 | Level 5 | 1.8555 | 0.000261727 | 0.10642
3034289 | Level 5 | 1.10942 | 0.000261717 | 0.0636293
3034290 | Level 5 | 0.017438 | 0.000261727 | 0.00100014
3034291 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3034292 | Level 5 | 0.208769 | 0.000261727 | 0.0119737
3034297 | Level 5 | 0.704326 | 0.000261727 | 0.0403957
3034298 | Level 5 | 0.193638 | 0.000261727 | 0.0111059
3034299 | Level 5 | 0.657257 | 0.000261717 | 0.0376961
3034300 | Level 5 | 0.102445 | 0.000261727 | 0.0058756
3034301 | Level 5 | 0.0893379 | 0.000261727 | 0.00512386
3034304 | Level 5 | 0.182857 | 0.000261727 | 0.0104875
3034306 | Level 5 | 0.158503 | 0.000261727 | 0.00909073
3034309 | Level 5 | 0.202181 | 0.000261727 | 0.0115958
3034310 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034311 | Level 5 | 0.075 | 0.000261727 | 0.00430153
3034314 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034317 | Level 5 | 0.571415 | 0.000261727 | 0.0327727
3034324 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034325 | Level 5 | 0.0234188 | 0.000261727 | 0.00134315
3034328 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034331 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034332 | Level 5 | 0.0234188 | 0.000261727 | 0.00134315
3034335 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034338 | Level 5 | 0.14887 | 0.000261727 | 0.00853825
3034343 | Level 5 | 1.75852 | 0.000261727 | 0.100858
3034347 | Level 5 | 0.286521 | 0.000261727 | 0.0164331
3034348 | Level 5 | 0.6963 | 0.000261727 | 0.0399354
3034354 | Level 5 | 1.11439 | 0.000445281 | 0.0833666
3034355 | Level 5 | 0.00675666 | 0.000445281 | 0.00050546
3034356 | Level 5 | 1.23982 | 0.000445281 | 0.0927499
3034357 | Level 5 | 6.573 | 0.000445281 | 0.491721
3034358 | Level 5 | 0.1985 | 0.000445265 | 0.0148496
3034359 | Level 5 | 0.2055 | 0.000445281 | 0.0153733
3034360 | Level 5 | 0.599014 | 0.000445281 | 0.0448118
3034361 | Level 5 | 3.25912 | 0.000445281 | 0.243812
3034362 | Level 5 | 1.9333 | 0.000261727 | 0.110882
3034363 | Level 5 | 0.424815 | 0.000261727 | 0.0243647
3034366 | Level 5 | 0.00269577 | 0.000445281 | 0.000201668
3034367 | Level 5 | 0.0179324 | 0.000445281 | 0.00134151
3034370 | Level 5 | 0.00269577 | 0.000445281 | 0.000201668
3034373 | Level 5 | 2.23222 | 0.000445281 | 0.16699
3034382 | Level 5 | 0.0115765 | 0.000261727 | 0.000663952
3034383 | Level 5 | 0.2 | 0.000261727 | 0.0114707
3034386 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034389 | Level 5 | 0.017729 | 0.000261727 | 0.00101682
3034392 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034393 | Level 5 | 0.0179324 | 0.000261727 | 0.00102849
3034396 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034399 | Level 5 | 0.291829 | 0.000261727 | 0.0167375
3034409 | Level 5 | 0.241091 | 0.000261727 | 0.0138274
3034410 | Level 5 | 1.35873 | 0.000261727 | 0.0779281
3034421 | Level 5 | 0.0387593 | 0.000261727 | 0.00222299
3034422 | Level 5 | 0.947858 | 0.000261727 | 0.0543631
3034424 | Level 5 | 0.0509781 | 0.000261727 | 0.00292378
3034425 | Level 5 | 0.0996307 | 0.000261727 | 0.00571419
3034428 | Level 5 | 0.33634 | 0.000261727 | 0.0192903
3034431 | Level 5 | 0.0996307 | 0.000261727 | 0.00571419
3034436 | Level 5 | 0.444809 | 0.000261727 | 0.0255115
3034438 | Level 5 | 0.0387586 | 0.000261727 | 0.00222295
3034439 | Level 5 | 0.947857 | 0.000261727 | 0.0543631
3034441 | Level 5 | 0.0509781 | 0.000261727 | 0.00292378
3034442 | Level 5 | 0.0996307 | 0.000261727 | 0.00571419
3034445 | Level 5 | 0.33634 | 0.000261727 | 0.0192903
3034448 | Level 5 | 0.0996307 | 0.000261727 | 0.00571419
3034453 | Level 5 | 0.444809 | 0.000261727 | 0.0255115
3034456 | Level 5 | 0.0387586 | 0.000261727 | 0.00222295
3034457 | Level 5 | 0.947857 | 0.000261727 | 0.0543631
3034458 | Level 5 | 0.0509781 | 0.000261727 | 0.00292378
3034459 | Level 5 | 0.0996307 | 0.000261727 | 0.00571419
3034462 | Level 5 | 0.33634 | 0.000261727 | 0.0192903
3034465 | Level 5 | 0.0996307 | 0.000261727 | 0.00571419
3034470 | Level 5 | 0.444809 | 0.000261727 | 0.0255115
3034472 | Level 5 | 0.0387593 | 0.000261727 | 0.00222299
3034473 | Level 5 | 0.947858 | 0.000261727 | 0.0543631
3034475 | Level 5 | 0.0509781 | 0.000261727 | 0.00292378
3034476 | Level 5 | 0.0996307 | 0.000261727 | 0.00571419
3034479 | Level 5 | 0.33634 | 0.000261727 | 0.0192903
3034482 | Level 5 | 0.0996307 | 0.000261727 | 0.00571419
3034487 | Level 5 | 0.444809 | 0.000261727 | 0.0255115
3034490 | Level 5 | 0.464617 | 0.000261727 | 0.0266475
3034493 | Level 5 | 0.502215 | 0.000261727 | 0.0288039
3034496 | Level 5 | 0.492204 | 0.000261727 | 0.0282297
3034499 | Level 5 | 0.502201 | 0.000261727 | 0.0288031
3034509 | Level 5 | 0.0118369 | 0.000261727 | 0.000678892
3034510 | Level 5 | 2.04169 | 0.000261727 | 0.117099
3034519 | Level 5 | 0.0119369 | 0.000261727 | 0.000684623
3034526 | Level 5 | 0.706826 | 0.000261727 | 0.0405391
3034529 | Level 5 | 0.743669 | 0.000261727 | 0.0426522
3034530 | Level 5 | 0.0119369 | 0.000261727 | 0.000684623
3034537 | Level 5 | 0.767057 | 0.000261727 | 0.0439936
3034542 | Level 5 | 0.00783803 | 0.000261727 | 0.00044954
3034543 | Level 5 | 0.250638 | 0.000261727 | 0.014375
3034548 | Level 5 | 0.0130309 | 0.000261727 | 0.000747368
3034551 | Level 5 | 0.0111381 | 0.000261727 | 0.000638809
3034552 | Level 5 | 0.631374 | 0.000261727 | 0.0362116
3034575 | Level 5 | 0.0303379 | 0.000261727 | 0.00173999
3034580 | Level 5 | 0.636683 | 0.000261727 | 0.0365161
3034581 | Level 5 | 0.030338 | 0.000261727 | 0.00174
3034588 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034589 | Level 5 | 0.125 | 0.000261727 | 0.00716921
3034592 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034595 | Level 5 | 0.0399794 | 0.000261727 | 0.00229297
3034604 | Level 5 | 0.952057 | 0.000261727 | 0.054604
3034611 | Level 5 | 1.59457 | 0.000261727 | 0.0914544
3034616 | Level 5 | 0.188638 | 0.000261727 | 0.0108191
3034619 | Level 5 | 0.360934 | 0.000261727 | 0.0207009
3034622 | Level 5 | 0.0228375 | 0.000261717 | 0.00130982
3034625 | Level 5 | 2.04172 | 0.000261727 | 0.1171
3034634 | Level 5 | 0.0129394 | 0.000261727 | 0.000742123
3034635 | Level 5 | 0.743602 | 0.000261727 | 0.0426483
3034644 | Level 5 | 0.0129353 | 0.000261717 | 0.000741885
3034651 | Level 5 | 0.767057 | 0.000261727 | 0.0439936
3034656 | Level 5 | 0.0128395 | 0.000261727 | 0.000736393
3034659 | Level 5 | 0.048 | 0.000261727 | 0.00275298
3034662 | Level 5 | 0.755503 | 0.000261727 | 0.0433309
3034663 | Level 5 | 0.80457 | 0.000261727 | 0.0461451
3034668 | Level 5 | 0.253138 | 0.000261727 | 0.0145184
3034675 | Level 5 | 0.0130309 | 0.000261727 | 0.000747368
3034688 | Level 5 | 0.0261415 | 0.000261727 | 0.00149931
3034689 | Level 5 | 0.631373 | 0.000261727 | 0.0362116
3034698 | Level 5 | 0.254571 | 0.000261727 | 0.0146006
3034699 | Level 5 | 0.21706 | 0.000261727 | 0.0124492
3034700 | Level 5 | 0.0303402 | 0.000261727 | 0.00174012
3034701 | Level 5 | 0.636683 | 0.000261727 | 0.0365161
3034702 | Level 5 | 0.0303369 | 0.000261727 | 0.00173993
3034703 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034704 | Level 5 | 0.125 | 0.000261727 | 0.00716921
3034707 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034710 | Level 5 | 0.0399794 | 0.000261727 | 0.00229297
3034731 | Level 5 | 0.00788792 | 0.000261727 | 0.000452401
3034732 | Level 5 | 0.193138 | 0.000261727 | 0.0110772
3034741 | Level 5 | 1.06711 | 0.000261727 | 0.0612025
3034742 | Level 5 | 1.59457 | 0.000261727 | 0.0914544
3034745 | Level 5 | 1.04707 | 0.000261727 | 0.0600531
3034746 | Level 5 | 1.03611 | 0.000261727 | 0.0594246
3034747 | Level 5 | 0.27545 | 0.000261727 | 0.0157981
3034748 | Level 5 | 3.2319 | 0.000261727 | 0.185361
3034753 | Level 5 | 0.0168252 | 0.000261727 | 0.000964988
3034754 | Level 5 | 2.04171 | 0.000261727 | 0.1171
3034767 | Level 5 | 0.699326 | 0.000261727 | 0.0401089
3034768 | Level 5 | 0.743652 | 0.000261727 | 0.0426512
3034773 | Level 5 | 0.0169369 | 0.000261727 | 0.000971391
3034776 | Level 5 | 0.804569 | 0.000261727 | 0.046145
3034777 | Level 5 | 0.804569 | 0.000261717 | 0.046145
3034782 | Level 5 | 0.767057 | 0.000261727 | 0.0439936
3034789 | Level 5 | 0.00783877 | 0.000261727 | 0.000449583
3034798 | Level 5 | 0.048 | 0.000261727 | 0.00275298
3034805 | Level 5 | 0.0205541 | 0.000261727 | 0.00117885
3034818 | Level 5 | 0.0161354 | 0.000261727 | 0.000925423
3034825 | Level 5 | 0.254571 | 0.000261727 | 0.0146006
3034826 | Level 5 | 0.0303402 | 0.000261727 | 0.00174012
3034827 | Level 5 | 0.636683 | 0.000261727 | 0.0365161
3034828 | Level 5 | 0.0301287 | 0.000261727 | 0.00172799
3034829 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034830 | Level 5 | 0.125 | 0.000261727 | 0.00716921
3034833 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034836 | Level 5 | 0.0399794 | 0.000261727 | 0.00229297
3034853 | Level 5 | 0.204391 | 0.000261727 | 0.0117226
3034860 | Level 5 | 1.59457 | 0.000261727 | 0.0914544
3034861 | Level 5 | 0.196942 | 0.000261727 | 0.0112954
3034868 | Level 5 | 0.0183334 | 0.000261727 | 0.00105149
3034869 | Level 5 | 2.04219 | 0.000261727 | 0.117127
3034882 | Level 5 | 0.684326 | 0.000261727 | 0.0392486
3034885 | Level 5 | 0.743669 | 0.000261727 | 0.0426522
3034892 | Level 5 | 0.0229379 | 0.000261727 | 0.00131557
3034899 | Level 5 | 0.021137 | 0.000261727 | 0.00121229
3034911 | Level 5 | 0.00803087 | 0.000261727 | 0.0004606
3034930 | Level 5 | 0.048 | 0.000261727 | 0.00275298
3034931 | Level 5 | 0.00836907 | 0.000261727 | 0.000479997
3034938 | Level 5 | 0.767057 | 0.000261727 | 0.0439936
3034943 | Level 5 | 0.254569 | 0.000261727 | 0.0146005
3034944 | Level 5 | 0.0303379 | 0.000261727 | 0.00173999
3034945 | Level 5 | 0.636683 | 0.000261727 | 0.0365161
3034946 | Level 5 | 0.0301411 | 0.000261727 | 0.0017287
3034947 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034948 | Level 5 | 0.125 | 0.000261727 | 0.00716921
3034951 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3034954 | Level 5 | 0.0399794 | 0.000261727 | 0.00229297
3034969 | Level 5 | 0.188638 | 0.000261727 | 0.0108191
3034978 | Level 5 | 1.06711 | 0.000261727 | 0.0612025
3034979 | Level 5 | 1.59457 | 0.000261727 | 0.0914544
3034984 | Level 5 | 0.285509 | 0.000261727 | 0.016375
3034987 | Level 5 | 1.04706 | 0.000261727 | 0.0600526
3034990 | Level 5 | 2.84962 | 0.000261727 | 0.163436
3034991 | Level 5 | 2.87235 | 0.000261727 | 0.16474
3034992 | Level 5 | 2.84568 | 0.000445281 | 0.212883
3034993 | Level 5 | 0.258057 | 0.000261727 | 0.0148005
3034994 | Level 5 | 0.258057 | 0.000261727 | 0.0148005
3034995 | Level 5 | 0.25285 | 0.000445281 | 0.0189155
3034996 | Level 5 | 0.269062 | 0.000445281 | 0.0201283
3034997 | Level 5 | 0.244596 | 0.000261727 | 0.0140285
3034998 | Level 5 | 0.214512 | 0.000261727 | 0.0123031
3034999 | Level 5 | 0.0255161 | 0.000445281 | 0.00190884
3035000 | Level 5 | 0.273143 | 0.000445281 | 0.0204336
3035003 | Level 5 | 0.0255161 | 0.000445281 | 0.00190884
3035006 | Level 5 | 0.0531472 | 0.000445281 | 0.0039759
3035011 | Level 5 | 0.05832 | 0.000261727 | 0.00334487
3035012 | Level 5 | 0.0277886 | 0.000261727 | 0.00159378
3035013 | Level 5 | 0.0751356 | 0.000261727 | 0.0043093
3035016 | Level 5 | 0.0277886 | 0.000261727 | 0.00159378
3035023 | Level 5 | 0.0115765 | 0.000261727 | 0.000663952
3035024 | Level 5 | 3.3027 | 0.000261727 | 0.189422
3035025 | Level 5 | 0.0125953 | 0.000445281 | 0.000942241
3035026 | Level 5 | 0.0277886 | 0.000261727 | 0.00159378
3035027 | Level 5 | 0.195169 | 0.000261727 | 0.0111936
3035036 | Level 5 | 0.0115765 | 0.000261727 | 0.000663952
3035037 | Level 5 | 0.0277886 | 0.000261727 | 0.00159378
3035038 | Level 5 | 0.195169 | 0.000261727 | 0.0111936
3035043 | Level 5 | 1.15372 | 0.000261727 | 0.0661699
3035054 | Level 5 | 0.0288274 | 0.000445281 | 0.00215656
3035055 | Level 5 | 0.192491 | 0.000445281 | 0.0144001
3035074 | Level 5 | 0.0315074 | 0.000261727 | 0.00180706
3035075 | Level 5 | 0.695638 | 0.000261727 | 0.0398974
3035078 | Level 5 | 0.356826 | 0.000261727 | 0.0204653
3035083 | Level 5 | 0.0314726 | 0.000261727 | 0.00180507
3035084 | Level 5 | 0.695638 | 0.000261727 | 0.0398974
3035085 | Level 5 | 0.356923 | 0.000261727 | 0.0204708
3035094 | Level 5 | 0.0316382 | 0.000261727 | 0.00181457
3035095 | Level 5 | 0.695638 | 0.000261727 | 0.0398974
3035096 | Level 5 | 0.356495 | 0.000261727 | 0.0204463
3035099 | Level 5 | 0.0315588 | 0.000261727 | 0.00181001
3035100 | Level 5 | 0.695638 | 0.000261727 | 0.0398974
3035101 | Level 5 | 0.356436 | 0.000261727 | 0.0204429
3035116 | Level 5 | 0.279532 | 0.000261727 | 0.0160322
3035117 | Level 5 | 0.0475876 | 0.000261727 | 0.00272933
3035118 | Level 5 | 0.0363541 | 0.000261727 | 0.00208504
3035127 | Level 5 | 0.250299 | 0.000261727 | 0.0143556
3035128 | Level 5 | 0.0475876 | 0.000261727 | 0.00272933
3035129 | Level 5 | 0.0771443 | 0.000261727 | 0.00442451
3035138 | Level 5 | 0.269295 | 0.000261727 | 0.0154451
3035139 | Level 5 | 0.0475876 | 0.000261727 | 0.00272933
3035140 | Level 5 | 0.0581536 | 0.000261727 | 0.00333532
3035147 | Level 5 | 0.15765 | 0.000261727 | 0.00904183
3035148 | Level 5 | 0.0490018 | 0.000261727 | 0.00281044
3035149 | Level 5 | 0.081437 | 0.000261727 | 0.00467071
3035156 | Level 5 | 0.817376 | 0.000261717 | 0.0468795
3035157 | Level 5 | 0.0045054 | 0.000261727 | 0.000258402
3035158 | Level 5 | 0.455819 | 0.000261727 | 0.0261429
3035167 | Level 5 | 0.221123 | 0.000261727 | 0.0126822
3035168 | Level 5 | 0.0242115 | 0.000261727 | 0.00138862
3035169 | Level 5 | 0.330327 | 0.000261727 | 0.0189455
3035172 | Level 5 | 0.024215 | 0.000261727 | 0.00138882
3035175 | Level 5 | 0.680212 | 0.000261727 | 0.0390127
3035184 | Level 5 | 0.514375 | 0.000261717 | 0.0295013
3035185 | Level 5 | 0.0419308 | 0.000261727 | 0.00240488
3035186 | Level 5 | 0.184076 | 0.000261727 | 0.0105574
3035189 | Level 5 | 0.0724778 | 0.000261727 | 0.00415687
3035192 | Level 5 | 0.556051 | 0.000261727 | 0.0318916
3035201 | Level 5 | 0.538454 | 0.000261727 | 0.0308823
3035202 | Level 5 | 0.00450551 | 0.000261727 | 0.000258408
3035203 | Level 5 | 0.0825002 | 0.000261727 | 0.00473169
3035206 | Level 5 | 0.0327894 | 0.000261727 | 0.0018806
3035209 | Level 5 | 0.602073 | 0.000261727 | 0.0345311
3035218 | Level 5 | 0.737436 | 0.000261727 | 0.0422947
3035219 | Level 5 | 0.0101622 | 0.000261727 | 0.000582842
3035220 | Level 5 | 0.05 | 0.000261727 | 0.00286769
3035223 | Level 5 | 0.0101622 | 0.000261727 | 0.000582842
3035226 | Level 5 | 0.264814 | 0.000261727 | 0.0151881
3035237 | Level 5 | 0.737436 | 0.000261717 | 0.0422947
3035238 | Level 5 | 0.0101622 | 0.000261727 | 0.000582842
3035239 | Level 5 | 0.05 | 0.000261727 | 0.00286769
3035242 | Level 5 | 0.0101622 | 0.000261727 | 0.000582842
3035245 | Level 5 | 0.264814 | 0.000261727 | 0.0151881
3035254 | Level 5 | 0.253257 | 0.000261727 | 0.0145253
3035255 | Level 5 | 0.0101622 | 0.000261727 | 0.000582842
3035256 | Level 5 | 0.05 | 0.000261727 | 0.00286769
3035259 | Level 5 | 0.0101622 | 0.000261727 | 0.000582842
3035262 | Level 5 | 0.737436 | 0.000261727 | 0.0422947
3035271 | Level 5 | 0.0219966 | 0.000261727 | 0.00126159
3035272 | Level 5 | 1.07863 | 0.000261727 | 0.0618632
3035275 | Level 5 | 0.836436 | 0.000261727 | 0.0479727
3035278 | Level 5 | 0.163814 | 0.000261727 | 0.00939536
3035279 | Level 5 | 0.0115765 | 0.000261727 | 0.000663952
3035280 | Level 5 | 0.05 | 0.000261727 | 0.00286769
3035283 | Level 5 | 0.0115765 | 0.000261727 | 0.000663952
3035294 | Level 5 | 0.685939 | 0.000261727 | 0.0393411
3035295 | Level 5 | 0.00450199 | 0.000261727 | 0.000258206
3035296 | Level 5 | 0.0499976 | 0.000261727 | 0.00286755
3035299 | Level 5 | 0.00450368 | 0.000261727 | 0.000258303
3035302 | Level 5 | 0.0573411 | 0.000261727 | 0.00328872
3035309 | Level 5 | 0.686053 | 0.000261727 | 0.0393477
3035310 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3035311 | Level 5 | 0.05 | 0.000261727 | 0.00286769
3035314 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3035317 | Level 5 | 0.0455759 | 0.000261717 | 0.00261395
3035326 | Level 5 | 0.0480437 | 0.000261727 | 0.00275549
3035327 | Level 5 | 0.00450392 | 0.000261727 | 0.000258316
3035328 | Level 5 | 0.0499979 | 0.000261727 | 0.00286757
3035331 | Level 5 | 0.0045024 | 0.000261727 | 0.000258229
3035334 | Level 5 | 0.675021 | 0.000261727 | 0.038715
3035343 | Level 5 | 0.0518201 | 0.000261727 | 0.00297207
3035344 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3035345 | Level 5 | 0.05 | 0.000261727 | 0.00286769
3035348 | Level 5 | 0.00450538 | 0.000261727 | 0.0002584
3035351 | Level 5 | 0.68655 | 0.000261727 | 0.0393762
3035360 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035361 | Level 5 | 0.175 | 0.000261727 | 0.0100369
3035364 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035367 | Level 5 | 0.0611205 | 0.000261727 | 0.00350548
3035368 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035369 | Level 5 | 0.175 | 0.000261727 | 0.0100369
3035372 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035375 | Level 5 | 0.0611205 | 0.000261727 | 0.00350548
3035388 | Level 5 | 0.0483648 | 0.000261727 | 0.0027739
3035389 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035390 | Level 5 | 0.14625 | 0.000261727 | 0.00838798
3035393 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035396 | Level 5 | 0.757407 | 0.000261727 | 0.0434401
3035397 | Level 5 | 0.0483648 | 0.000261727 | 0.0027739
3035398 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035399 | Level 5 | 0.14625 | 0.000261727 | 0.00838798
3035402 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035405 | Level 5 | 1.17889 | 0.000261727 | 0.0676139
3035422 | Level 5 | 1.17815 | 0.000261727 | 0.0675715
3035423 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035424 | Level 5 | 0.145 | 0.000261727 | 0.00831629
3035427 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035430 | Level 5 | 0.061911 | 0.000261727 | 0.00355082
3035431 | Level 5 | 0.756668 | 0.000261727 | 0.0433977
3035432 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035433 | Level 5 | 0.145 | 0.000261727 | 0.00831629
3035436 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035439 | Level 5 | 0.061911 | 0.000261727 | 0.00355082
3035454 | Level 5 | 0.0433648 | 0.000261727 | 0.00248713
3035455 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035456 | Level 5 | 0.1675 | 0.000261727 | 0.00960674
3035459 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035462 | Level 5 | 0.741157 | 0.000261727 | 0.0425081
3035463 | Level 5 | 0.0433648 | 0.000261727 | 0.00248713
3035464 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035465 | Level 5 | 0.1675 | 0.000261727 | 0.00960674
3035468 | Level 5 | 0.0327897 | 0.000261727 | 0.00188061
3035471 | Level 5 | 1.16264 | 0.000261727 | 0.0666819
3035489 | Level 5 | 0.774569 | 0.000261727 | 0.0444244
3035494 | Level 5 | 0.0752445 | 0.000261727 | 0.00431555
3035495 | Level 5 | 1.36611 | 0.000261727 | 0.0783517
3035498 | Level 5 | 1.13386 | 0.000261727 | 0.065031
3035502 | Level 5 | 0.774569 | 0.000261727 | 0.0444244
3035507 | Level 5 | 0.075193 | 0.000261727 | 0.0043126
3035508 | Level 5 | 1.36536 | 0.000261727 | 0.0783087
3035511 | Level 5 | 0.754569 | 0.000261727 | 0.0432773
3035516 | Level 5 | 0.073057 | 0.000261727 | 0.00419009
3035517 | Level 5 | 1.36611 | 0.000261727 | 0.0783517
3035520 | Level 5 | 1.13386 | 0.000261727 | 0.065031
3035524 | Level 5 | 0.774569 | 0.000261727 | 0.0444244
3035531 | Level 5 | 0.0756929 | 0.000261727 | 0.00434127
3035532 | Level 5 | 1.36531 | 0.000261727 | 0.0783058
3035535 | Level 5 | 1.13386 | 0.000261727 | 0.065031
3035538 | Level 5 | 1.13386 | 0.000261727 | 0.065031

# IfcCableCarrierSegment: Conduit with Fittings:PVC (SCH-40), Conduit with Fittings:PVC (SCH-40):1510345
In: Level 2
Type - PredefinedType: CONDUITSEGMENT
Classification: D5020.30 Uniformat (Uniformat)
Pset_CableCarrierSegmentTypeCommon - Reference: PVC (SCH-40); sets with these values: 2
Qto_CableCarrierSegmentBaseQuantities - Length: 1.49977 m; CrossSectionArea: 0.000677323 m2; OuterSurfaceArea: 0.138375 m2

# IfcCovering: Basic Ceiling:Generic (3)
Type - PredefinedType: CEILING
Type - Pset_CoveringCommon - IsExternal: no
Pset_CoveringCommon - Reference: Generic
Pset_EnvironmentalImpactIndicators - Reference: Generic
Name (Basic Ceiling:Generic:...) | In
2693369 | Level 3
2693379 | Level 4
2693389 | Level 5

# IfcDistributionPort (15965)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | PredefinedType | SystemType
Port_1489141_2 | CABLE | ELECTRICAL
Port_1489142_2 | CABLE | ELECTRICAL
Port_1489143_6 | CABLE | ELECTRICAL
Port_1489144_2 | CABLE | ELECTRICAL
Port_1489145_2 | CABLE | ELECTRICAL
Port_1489146_2 | CABLE | ELECTRICAL
Port_1489147_2 | CABLE | ELECTRICAL
Port_1489148_6 | CABLE | ELECTRICAL
Port_1489149_8 | CABLE | DATA
Port_1489150_1 | CABLE | ELECTRICAL
Port_1489151_2 | CABLE | ELECTRICAL
Port_1489152_2 | CABLE | ELECTRICAL
Port_1489153_6 | CABLE | ELECTRICAL
Port_1489154_1 | CABLE | ELECTRICAL
Port_1489155_1 | CABLE | ELECTRICAL
Port_1489156_2 | CABLE | ELECTRICAL
Port_1489157_2 | CABLE | ELECTRICAL
Port_1489158_6 | CABLE | ELECTRICAL
Port_1489159_6 | CABLE | ELECTRICAL
Port_1489160_1 | CABLE | ELECTRICAL
Port_1489161_8 | CABLE | DATA
Port_1489162_8 | CABLE | COMMUNICATION
Port_1489163_2 | CABLE | ELECTRICAL
Port_1489164_1 | CABLE | ELECTRICAL
Port_1489165_2 | CABLE | ELECTRICAL
Port_1489166_6 | CABLE | ELECTRICAL
Port_1489167_1 | CABLECARRIER | CONVEYING
Port_2065291_1 | CABLECARRIER | CONVEYING
Port_1489169_1 | CABLECARRIER | CONVEYING
Port_2065254_1 | CABLECARRIER | CONVEYING
Port_1489171_1 | CABLECARRIER | CONVEYING
Port_1490102_1 | CABLECARRIER | CONVEYING
Port_1489175_1 | CABLECARRIER | CONVEYING
Port_2068043_1 | CABLECARRIER | CONVEYING
Port_1489177_1 | CABLECARRIER | CONVEYING
Port_2068012_1 | CABLECARRIER | CONVEYING
Port_1489179_1 | CABLECARRIER | CONVEYING
Port_2069830_1 | CABLECARRIER | CONVEYING
Port_1489181_0 | CABLECARRIER | CONVEYING
Port_2069851_1 | CABLECARRIER | CONVEYING
Port_1489181_1 | CABLECARRIER | CONVEYING
Port_2069853_2 | CABLECARRIER | CONVEYING
Port_1489184_1 | CABLECARRIER | CONVEYING
Port_1490134_1 | CABLECARRIER | CONVEYING
Port_1489192_0 | CABLECARRIER | CONVEYING
Port_1490132_1 | CABLECARRIER | CONVEYING
Port_1489192_1 | CABLECARRIER | CONVEYING
Port_1490134_2 | CABLECARRIER | CONVEYING
Port_1489203_0 | CABLECARRIER | CONVEYING
Port_2076905_1 | CABLECARRIER | CONVEYING
Port_1489205_0 | CABLECARRIER | CONVEYING
Port_1493766_1 | CABLECARRIER | CONVEYING
Port_1489208_1 | CABLECARRIER | CONVEYING
Port_1489362_1 | CABLECARRIER | CONVEYING
Port_1489214_0 | CABLECARRIER | CONVEYING
Port_1523057_2 | CABLECARRIER | CONVEYING
Port_1489214_1 | CABLECARRIER | CONVEYING
Port_1523059_2 | CABLECARRIER | CONVEYING
Port_1489222_0 | CABLECARRIER | CONVEYING
Port_1492242_1 | CABLECARRIER | CONVEYING
Port_1489232_0 | CABLECARRIER | CONVEYING
Port_2071083_1 | CABLECARRIER | CONVEYING
Port_1489234_0 | CABLECARRIER | CONVEYING
Port_1492546_1 | CABLECARRIER | CONVEYING
Port_1489242_0 | CABLECARRIER | CONVEYING
Port_1492242_2 | CABLECARRIER | CONVEYING
Port_1489244_1 | CABLECARRIER | CONVEYING
Port_2075247_1 | CABLECARRIER | CONVEYING
Port_1489246_1 | CABLECARRIER | CONVEYING
Port_1492542_1 | CABLECARRIER | CONVEYING
Port_1489248_1 | CABLECARRIER | CONVEYING
Port_2103383_1 | CABLECARRIER | CONVEYING
Port_1489250_0 | CABLECARRIER | CONVEYING
Port_2103385_2 | CABLECARRIER | CONVEYING
Port_1489250_1 | CABLECARRIER | CONVEYING
Port_2103388_2 | CABLECARRIER | CONVEYING
Port_1489254_0 | CABLECARRIER | CONVEYING
Port_1523082_1 | CABLECARRIER | CONVEYING
Port_1489262_1 | CABLE | ELECTRICAL
Port_1489263_1 | CABLE | ELECTRICAL
Port_1489265_0 | CABLECARRIER | CONVEYING
Port_2103421_1 | CABLECARRIER | CONVEYING
Port_1489267_0 | CABLECARRIER | CONVEYING
Port_2601069_1 | CABLECARRIER | CONVEYING
Port_1489269_1 | CABLE | ELECTRICAL
Port_1489271_0 | CABLECARRIER | CONVEYING
Port_1489275_2 | CABLECARRIER | CONVEYING
Port_1489273_1 | CABLECARRIER | CONVEYING
Port_1489275_1 | CABLECARRIER | CONVEYING
Port_1489277_0 | CABLECARRIER | CONVEYING
Port_2601040_2 | CABLECARRIER | CONVEYING
Port_1489277_1 | CABLECARRIER | CONVEYING
Port_1522441_2 | CABLECARRIER | CONVEYING
Port_1489281_0 | CABLECARRIER | CONVEYING
Port_1494478_1 | CABLECARRIER | CONVEYING
Port_1489281_1 | CABLECARRIER | CONVEYING
Port_1494480_2 | CABLECARRIER | CONVEYING
Port_1489285_0 | CABLECARRIER | CONVEYING
Port_2847226_2 | CABLECARRIER | CONVEYING
Port_1489289_1 | CABLECARRIER | CONVEYING
Port_2619991_1 | CABLECARRIER | CONVEYING
Port_1489291_0 | CABLECARRIER | CONVEYING
Port_2847226_1 | CABLECARRIER | CONVEYING
Port_1489291_1 | CABLECARRIER | CONVEYING
Port_2620016_2 | CABLECARRIER | CONVEYING
Port_1489303_0 | CABLECARRIER | CONVEYING
Port_2103430_1 | CABLECARRIER | CONVEYING
Port_1489303_1 | CABLECARRIER | CONVEYING
Port_2103432_2 | CABLECARRIER | CONVEYING
Port_1489305_0 | CABLECARRIER | CONVEYING
Port_2103432_1 | CABLECARRIER | CONVEYING
Port_1489305_1 | CABLECARRIER | CONVEYING
Port_2847594_1 | CABLECARRIER | CONVEYING
Port_1489311_1 | CABLECARRIER | CONVEYING
Port_1489315_1 | CABLECARRIER | CONVEYING
Port_1489313_0 | CABLECARRIER | CONVEYING
Port_1489315_2 | CABLECARRIER | CONVEYING
Port_1489313_1 | CABLECARRIER | CONVEYING
Port_1522255_1 | CABLECARRIER | CONVEYING
Port_1489317_0 | CABLECARRIER | CONVEYING
Port_1522255_2 | CABLECARRIER | CONVEYING
