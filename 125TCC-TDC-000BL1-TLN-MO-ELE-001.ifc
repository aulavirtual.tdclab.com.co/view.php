Properties of the parts of a building model (IFC4), part 5 of 18

# IfcCableCarrierSegment: Conduit with Fittings:PVC (4616)
Name (Conduit with Fittings:PVC:...) | In | Length (m) | CrossSectionArea (m2) | OuterSurfaceArea (m2)
2663490 | Level 6 | 0.14875 | 0.000261727 | 0.00853136
2663493 | Level 6 | 0.0356181 | 0.000261727 | 0.00204283
2663496 | Level 6 | 0.754157 | 0.000261727 | 0.0432537
2663853 | Level 6 | 0.750537 | 0.000261727 | 0.0430461
2663854 | Level 6 | 0.0356181 | 0.000261727 | 0.00204283
2663857 | Level 6 | 0.155 | 0.000261727 | 0.00888982
2663860 | Level 6 | 0.0356181 | 0.000261727 | 0.00204283
2663863 | Level 6 | 0.0540413 | 0.000261727 | 0.00309947
2663982 | Level 6 | 1.17202 | 0.000261727 | 0.0672199
2663983 | Level 6 | 0.0356181 | 0.000261727 | 0.00204283
2663986 | Level 6 | 0.155 | 0.000261727 | 0.00888982
2663989 | Level 6 | 0.0356181 | 0.000261727 | 0.00204283
2663992 | Level 6 | 0.0540914 | 0.000261727 | 0.00310234
2664889 | Level 6 | 0.75925 | 0.000261727 | 0.0435458
2664890 | Level 6 | 0.0327897 | 0.000261727 | 0.00188061
2664893 | Level 6 | 0.1625 | 0.000261727 | 0.00931998
2664896 | Level 6 | 0.0327897 | 0.000261727 | 0.00188061
2664899 | Level 6 | 0.0533858 | 0.000261727 | 0.00306188
2665008 | Level 6 | 1.18074 | 0.000261727 | 0.0677196
2665009 | Level 6 | 0.0327897 | 0.000261727 | 0.00188061
2665012 | Level 6 | 0.1625 | 0.000261727 | 0.00931998
2665015 | Level 6 | 0.0327897 | 0.000261727 | 0.00188061
2665018 | Level 6 | 0.0534359 | 0.000261727 | 0.00306475
2665462 | Level 6 | 0.0350461 | 0.000261727 | 0.00201002
2665463 | Level 6 | 0.0356181 | 0.000261727 | 0.00204283
2665466 | Level 6 | 0.18 | 0.000261727 | 0.0103237
2665469 | Level 6 | 0.0356181 | 0.000261727 | 0.00204283
2665472 | Level 6 | 0.744533 | 0.000261727 | 0.0427017
2665595 | Level 6 | 0.0350961 | 0.000261727 | 0.00201289
2665596 | Level 6 | 0.0356181 | 0.000261727 | 0.00204283
2665599 | Level 6 | 0.18 | 0.000261727 | 0.0103237
2665602 | Level 6 | 0.0356181 | 0.000261727 | 0.00204283
2665605 | Level 6 | 1.16602 | 0.000261727 | 0.0668755
2666163 | Level 6 | 0.261034 | 0.000261727 | 0.0149713
2666164 | Level 6 | 0.0257186 | 0.000261727 | 0.00147506
2666167 | Level 6 | 1.01 | 0.000261727 | 0.0579272
2666170 | Level 6 | 0.0257186 | 0.000261727 | 0.00147506
2666173 | Level 6 | 1.95926 | 0.000261727 | 0.112371
2668267 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2668270 | Level 2 | 0.1525 | 0.000261727 | 0.00874644
2668273 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2668276 | Level 2 | 0.299919 | 0.000261727 | 0.0172014
2668389 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2668392 | Level 2 | 0.1525 | 0.000261727 | 0.00874644
2668395 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2668398 | Level 2 | 0.0999186 | 0.000261727 | 0.0057307
2669053 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2669125 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2669212 | Level 2 | 3.52655 | 0.000261727 | 0.202261
2669770 | Level 2 | 3.51328 | 0.000261727 | 0.201499
2670295 | Level 2 | 3.47836 | 0.000445281 | 0.260213
2672863 | Level 6 | 1.74525 | 0.000261727 | 0.100097
2672864 | Level 6 | 0.0327897 | 0.000261727 | 0.00188061
2672867 | Level 6 | 1.2675 | 0.000261727 | 0.0726958
2672870 | Level 6 | 0.0327896 | 0.000261727 | 0.0018806
2672873 | Level 6 | 0.207545 | 0.000261727 | 0.0119035
2675528 | Level 6 | 0.231286 | 0.000261727 | 0.0132651
2675529 | Level 6 | 0.0327897 | 0.000261727 | 0.00188061
2675532 | Level 6 | 1.2525 | 0.000261727 | 0.0718355
2675535 | Level 6 | 0.0327897 | 0.000261727 | 0.00188061
2675538 | Level 6 | 1.73651 | 0.000261727 | 0.0995952
2677350 | Level 6 | 1.94522 | 0.000261727 | 0.111566
2677351 | Level 6 | 0.0327897 | 0.000261727 | 0.00188061
2677354 | Level 6 | 1.06287 | 0.000261727 | 0.0609596
2677357 | Level 6 | 0.0327897 | 0.000261727 | 0.00188061
2677360 | Level 6 | 0.212204 | 0.000261727 | 0.0121707
2683430 | Level 2 | 0.0917262 | 0.000677323 | 0.00846309
2781128 | Level 2 | 0.834668 | 0.000261727 | 0.0478713
2785847 | Level 2 | 1.31531 | 0.000261727 | 0.0754381
2786060 | Level 2 | 0.0751554 | 0.000261727 | 0.00431044
2813588 | Level 2 | 0.0751946 | 0.000261727 | 0.00431269
2813653 | Level 2 | 1.36531 | 0.000261727 | 0.0783058
2834845 | Level 2 | 0.0751946 | 0.000261727 | 0.00431269
2834914 | Level 2 | 1.36531 | 0.000261727 | 0.0783058
2845921 | Level 2 | 0.784767 | 0.000261727 | 0.0450093
2847518 | Level 2 | 0.754767 | 0.000261727 | 0.0432887
2851922 | Nivel 1 | 0.774569 | 0.000261727 | 0.0444244
2857422 | Nivel 1 | 0.0752445 | 0.000261727 | 0.00431555
2858067 | Nivel 1 | 1.36611 | 0.000261727 | 0.0783517
2858615 | Nivel 1 | 1.13386 | 0.000261727 | 0.065031
2863492 | Nivel 1 | 0.774569 | 0.000261727 | 0.0444244
2864195 | Nivel 1 | 0.075193 | 0.000261727 | 0.0043126
2864426 | Nivel 1 | 1.36536 | 0.000261727 | 0.0783087
2868602 | Nivel 1 | 0.754569 | 0.000261727 | 0.0432773
2868991 | Nivel 1 | 0.073057 | 0.000261727 | 0.00419009
2870171 | Nivel 1 | 1.36611 | 0.000261727 | 0.0783517
2870246 | Nivel 1 | 1.13386 | 0.000261727 | 0.065031
2873571 | Nivel 1 | 0.774569 | 0.000261727 | 0.0444244
2875696 | Nivel 1 | 0.0756929 | 0.000261727 | 0.00434127
2875720 | Nivel 1 | 1.36531 | 0.000261727 | 0.0783058
2880031 | Level 6 | 0.754569 | 0.000261727 | 0.0432773
2880245 | Level 6 | 0.075557 | 0.000261727 | 0.00433347
2881534 | Level 6 | 1.04611 | 0.000261727 | 0.0599985
2881600 | Level 6 | 0.0755586 | 0.000261727 | 0.00433356
2887113 | Level 6 | 0.754569 | 0.000261727 | 0.0432773
2887690 | Level 6 | 0.075557 | 0.000261727 | 0.00433347
2887756 | Level 6 | 1.04611 | 0.000261727 | 0.0599985
2889700 | Level 6 | 0.754569 | 0.000261727 | 0.0432773
2890303 | Level 6 | 0.073057 | 0.000261727 | 0.00419009
2891614 | Level 6 | 1.04611 | 0.000261727 | 0.0599985
2891652 | Level 6 | 0.0730586 | 0.000261727 | 0.00419018
2893376 | Level 6 | 0.754569 | 0.000261727 | 0.0432773
2893618 | Level 6 | 0.0805617 | 0.000261727 | 0.00462051
2894863 | Level 6 | 1.04611 | 0.000261727 | 0.0599985
2894882 | Level 6 | 0.0805632 | 0.000261727 | 0.0046206
2954890 | Level 2 | 1.59467 | 0.000261727 | 0.0914602
2956790 | Level 2 | 1.51703 | 0.000261727 | 0.0870071
2957583 | Level 2 | 1.57254 | 0.000261727 | 0.0901911
2958849 | Level 6 | 1.59453 | 0.000261727 | 0.0914521
2962356 | Level 2 | 1.13386 | 0.000261727 | 0.065031
2981039 | Level 2 | 1.12386 | 0.000261727 | 0.0644574
2984515 | Nivel 1 | 1.13386 | 0.000261727 | 0.065031
2987072 | Level 6 | 0.0755586 | 0.000261727 | 0.00433356
2989859 | Level 2 | 1.13386 | 0.000261727 | 0.065031
2991701 | Nivel 1 | 1.13386 | 0.000261727 | 0.065031
3025143 | Nivel 2 | 0.279115 | 0.000261727 | 0.0160083
3025144 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025145 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025146 | Nivel 2 | 0.0229341 | 0.000261727 | 0.00131535
3025147 | Nivel 2 | 1.15457 | 0.000261727 | 0.0662188
3025148 | Nivel 2 | 0.804569 | 0.000261727 | 0.046145
3025149 | Nivel 2 | 0.804569 | 0.000261727 | 0.046145
3025150 | Nivel 2 | 2.51533 | 0.000261717 | 0.144263
3025152 | Nivel 2 | 1.8555 | 0.000261727 | 0.10642
3025153 | Nivel 2 | 0.615816 | 0.000261727 | 0.0353193
3025155 | Nivel 2 | 0.998002 | 0.000261727 | 0.0572391
3025156 | Nivel 2 | 0.448 | 0.000261727 | 0.0256945
3025157 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025158 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025160 | Nivel 2 | 0.668585 | 0.000261727 | 0.0383458
3025161 | Nivel 2 | 1.51706 | 0.000261727 | 0.0870088
3025162 | Nivel 2 | 0.441527 | 0.000261727 | 0.0253232
3025164 | Nivel 2 | 1.048 | 0.000261727 | 0.0601068
3025165 | Nivel 2 | 0.1026 | 0.000261727 | 0.00588449
3025166 | Nivel 2 | 0.7926 | 0.000261727 | 0.0454585
3025167 | Nivel 2 | 0.767057 | 0.000261727 | 0.0439936
3025168 | Nivel 2 | 0.296722 | 0.000261727 | 0.0170181
3025169 | Nivel 2 | 0.0229379 | 0.000261727 | 0.00131557
3025170 | Nivel 2 | 0.0408 | 0.000261727 | 0.00234003
3025171 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025172 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025173 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025174 | Nivel 2 | 0.631383 | 0.000261727 | 0.0362121
3025175 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025176 | Nivel 2 | 0.0142587 | 0.000261727 | 0.000817789
3025181 | Nivel 2 | 0.804569 | 0.000261727 | 0.046145
3025182 | Nivel 2 | 0.767057 | 0.000261727 | 0.0439936
3025185 | Nivel 2 | 2.1564 | 0.000261727 | 0.123678
3025186 | Nivel 2 | 0.166402 | 0.000261727 | 0.00954375
3025189 | Nivel 2 | 0.17942 | 0.000261727 | 0.0102904
3025190 | Nivel 2 | 0.941555 | 0.000261727 | 0.0540017
3025191 | Nivel 2 | 2.69157 | 0.000261727 | 0.154372
3025192 | Nivel 2 | 1.3965 | 0.000261727 | 0.0800944
3025193 | Nivel 2 | 0.589 | 0.000261727 | 0.0337813
3025194 | Nivel 2 | 0.403493 | 0.000261717 | 0.0231418
3025195 | Nivel 2 | 0.012888 | 0.000261727 | 0.000739177
3025196 | Nivel 2 | 0.368727 | 0.000261727 | 0.0211479
3025197 | Nivel 2 | 0.0131379 | 0.000261727 | 0.000753508
3025198 | Nivel 2 | 1.11391 | 0.000261727 | 0.063887
3025201 | Nivel 2 | 0.324805 | 0.000261727 | 0.0186288
3025202 | Nivel 2 | 0.173109 | 0.000261727 | 0.00992845
3025203 | Nivel 2 | 0.0507798 | 0.000261727 | 0.00291241
3025204 | Nivel 2 | 1.8475 | 0.000261727 | 0.105961
3025206 | Nivel 2 | 1.548 | 0.000261727 | 0.0887836
3025208 | Nivel 2 | 0.4 | 0.000261727 | 0.0229415
3025209 | Nivel 2 | 0.391107 | 0.000261727 | 0.0224314
3025210 | Nivel 2 | 0.241107 | 0.000261727 | 0.0138284
3025211 | Nivel 2 | 0.767057 | 0.000261727 | 0.0439936
3025212 | Nivel 2 | 3.49886 | 0.000261727 | 0.200672
3025213 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025216 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025218 | Nivel 2 | 1.95457 | 0.000261727 | 0.112102
3025219 | Nivel 2 | 1.9055 | 0.000261727 | 0.109288
3025220 | Nivel 2 | 0.6355 | 0.000261727 | 0.0364483
3025221 | Nivel 2 | 1.09862 | 0.000261717 | 0.0630099
3025222 | Nivel 2 | 0.0174379 | 0.000261727 | 0.00100013
3025223 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025224 | Nivel 2 | 0.171257 | 0.000261727 | 0.00982222
3025229 | Nivel 2 | 0.0229379 | 0.000261727 | 0.00131557
3025230 | Nivel 2 | 0.273138 | 0.000261727 | 0.0156655
3025233 | Nivel 2 | 0.201138 | 0.000261727 | 0.011536
3025234 | Nivel 2 | 0.657257 | 0.000261727 | 0.0376961
3025237 | Nivel 2 | 0.097445 | 0.000261727 | 0.00558883
3025238 | Nivel 2 | 0.0843352 | 0.000261727 | 0.00483694
3025239 | Nivel 2 | 0.727458 | 0.000261727 | 0.0417224
3025240 | Nivel 2 | 0.182857 | 0.000261727 | 0.0104875
3025243 | Nivel 2 | 1.14894 | 0.000261727 | 0.0658962
3025245 | Nivel 2 | 0.158503 | 0.000261727 | 0.00909073
3025248 | Nivel 2 | 0.202183 | 0.000261727 | 0.011596
3025249 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025250 | Nivel 2 | 0.0875 | 0.000261727 | 0.00501845
3025253 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025256 | Nivel 2 | 0.563915 | 0.000261727 | 0.0323426
3025263 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025264 | Nivel 2 | 0.0234188 | 0.000261727 | 0.00134315
3025267 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025270 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025271 | Nivel 2 | 0.0234188 | 0.000261727 | 0.00134315
3025274 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025277 | Nivel 2 | 0.14887 | 0.000261727 | 0.00853825
3025282 | Nivel 2 | 1.75852 | 0.000261727 | 0.100858
3025311 | Nivel 2 | 0.278619 | 0.000261727 | 0.0159798
3025312 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025313 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025314 | Nivel 2 | 0.0164369 | 0.000261717 | 0.000942715
3025315 | Nivel 2 | 1.15457 | 0.000261727 | 0.0662188
3025316 | Nivel 2 | 0.804569 | 0.000261727 | 0.046145
3025317 | Nivel 2 | 0.804569 | 0.000261727 | 0.046145
3025318 | Nivel 2 | 2.52633 | 0.000261727 | 0.144894
3025320 | Nivel 2 | 1.8555 | 0.000261727 | 0.10642
3025321 | Nivel 2 | 0.615816 | 0.000261727 | 0.0353193
3025323 | Nivel 2 | 0.998002 | 0.000261727 | 0.0572391
3025324 | Nivel 2 | 0.448 | 0.000261727 | 0.0256945
3025325 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025326 | Nivel 2 | 0.2426 | 0.000261727 | 0.013914
3025328 | Nivel 2 | 0.66863 | 0.000261727 | 0.0383484
3025329 | Nivel 2 | 1.50553 | 0.000261727 | 0.0863477
3025330 | Nivel 2 | 0.42997 | 0.000261717 | 0.0246603
3025332 | Nivel 2 | 0.998002 | 0.000261727 | 0.0572391
3025333 | Nivel 2 | 0.048 | 0.000261727 | 0.00275298
3025334 | Nivel 2 | 0.1026 | 0.000261727 | 0.00588449
3025335 | Nivel 2 | 0.804569 | 0.000261717 | 0.046145
3025336 | Nivel 2 | 0.7555 | 0.000261727 | 0.0433307
3025337 | Nivel 2 | 0.296722 | 0.000261727 | 0.0170181
3025338 | Nivel 2 | 0.0408 | 0.000261727 | 0.00234003
3025339 | Nivel 2 | 0.254619 | 0.000261727 | 0.0146033
3025340 | Nivel 2 | 0.2055 | 0.000261727 | 0.0117862
3025341 | Nivel 2 | 0.2055 | 0.000261727 | 0.0117862
3025342 | Nivel 2 | 0.0142587 | 0.000261727 | 0.000817789
3025346 | Nivel 2 | 0.824569 | 0.000261727 | 0.0472921
3025347 | Nivel 2 | 0.7555 | 0.000261727 | 0.0433307
3025350 | Nivel 2 | 2.1564 | 0.000261727 | 0.123678
3025351 | Nivel 2 | 0.216402 | 0.000261727 | 0.0124114
3025354 | Nivel 2 | 0.679625 | 0.000261717 | 0.038979
3025355 | Nivel 2 | 0.941552 | 0.000261727 | 0.0540015
3025356 | Nivel 2 | 2.74157 | 0.000261717 | 0.157239
3025357 | Nivel 2 | 1.3965 | 0.000261727 | 0.0800944
3025358 | Nivel 2 | 0.589 | 0.000261727 | 0.0337813
3025359 | Nivel 2 | 0.405071 | 0.000261727 | 0.0232323
3025360 | Nivel 2 | 0.00571991 | 0.000261727 | 0.000328058
3025361 | Nivel 2 | 0.0175129 | 0.000261727 | 0.00100443
3025364 | Nivel 2 | 1.10235 | 0.000261727 | 0.0632241
3025367 | Nivel 2 | 0.443274 | 0.000261727 | 0.0254234
3025368 | Nivel 2 | 0.243454 | 0.000261727 | 0.013963
3025369 | Nivel 2 | 0.106348 | 0.000261727 | 0.00609945
3025370 | Nivel 2 | 1.8475 | 0.000261727 | 0.105961
3025374 | Nivel 2 | 0.4481 | 0.000261727 | 0.0257002
3025375 | Nivel 2 | 0.391107 | 0.000261727 | 0.0224314
3025376 | Nivel 2 | 0.32955 | 0.000261727 | 0.0189009
3025377 | Nivel 2 | 0.7555 | 0.000261727 | 0.0433307
3025378 | Nivel 2 | 3.4873 | 0.000261727 | 0.20001
3025379 | Nivel 2 | 0.2055 | 0.000261727 | 0.0117862
3025382 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025383 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025385 | Nivel 2 | 1.90457 | 0.000261727 | 0.109234
3025386 | Nivel 2 | 1.86706 | 0.000261727 | 0.107083
3025387 | Nivel 2 | 0.022438 | 0.000261727 | 0.0012869
3025388 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025389 | Nivel 2 | 0.171257 | 0.000261727 | 0.00982222
3025392 | Nivel 2 | 0.0119369 | 0.000261727 | 0.000684623
3025393 | Nivel 2 | 0.188638 | 0.000261727 | 0.0108191
3025394 | Nivel 2 | 0.6457 | 0.000261727 | 0.0370333
3025399 | Nivel 2 | 0.0635071 | 0.000261717 | 0.00364236
3025400 | Nivel 2 | 0.0893379 | 0.000261727 | 0.00512386
3025403 | Nivel 2 | 0.182857 | 0.000261727 | 0.0104875
3025409 | Nivel 2 | 0.158503 | 0.000261727 | 0.00909073
3025412 | Nivel 2 | 0.190632 | 0.000261727 | 0.0109334
3025413 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025414 | Nivel 2 | 0.05 | 0.000261727 | 0.00286769
3025417 | Nivel 2 | 0.00450539 | 0.000261727 | 0.000258401
3025420 | Nivel 2 | 0.112766 | 0.000261727 | 0.00646757
3025423 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025424 | Nivel 2 | 0.0234188 | 0.000261727 | 0.00134315
3025427 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025430 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025431 | Nivel 2 | 0.0234188 | 0.000261727 | 0.00134315
3025434 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025437 | Nivel 2 | 0.136901 | 0.000261727 | 0.00785178
3025444 | Nivel 2 | 1.74696 | 0.000261727 | 0.100195
3025451 | Nivel 2 | 0.297059 | 0.000261727 | 0.0170374
3025452 | Nivel 2 | 0.645459 | 0.000261727 | 0.0370195
3025455 | Nivel 2 | 1.04706 | 0.000261727 | 0.0600526
3025478 | Nivel 2 | 0.278619 | 0.000261727 | 0.0159798
3025479 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025480 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025481 | Nivel 2 | 0.0214432 | 0.000261727 | 0.00122985
3025482 | Nivel 2 | 1.15457 | 0.000261727 | 0.0662188
3025483 | Nivel 2 | 2.52133 | 0.000261727 | 0.144607
3025485 | Nivel 2 | 1.8555 | 0.000261727 | 0.10642
3025486 | Nivel 2 | 0.615816 | 0.000261727 | 0.0353193
3025488 | Nivel 2 | 0.85 | 0.000261727 | 0.0487506
3025489 | Nivel 2 | 0.335 | 0.000261727 | 0.0192135
3025490 | Nivel 2 | 0.195569 | 0.000261727 | 0.0112166
3025491 | Nivel 2 | 0.205569 | 0.000261727 | 0.0117901
3025493 | Nivel 2 | 0.639628 | 0.000261727 | 0.036685
3025494 | Nivel 2 | 1.51185 | 0.000261727 | 0.0867102
3025495 | Nivel 2 | 0.441527 | 0.000261717 | 0.0253232
3025497 | Nivel 2 | 1.048 | 0.000261727 | 0.0601068
3025498 | Nivel 2 | 0.102605 | 0.000261727 | 0.00588477
3025499 | Nivel 2 | 0.805 | 0.000261727 | 0.0461697
3025500 | Nivel 2 | 0.767058 | 0.000261727 | 0.0439936
3025501 | Nivel 2 | 0.296722 | 0.000261727 | 0.0170181
3025502 | Nivel 2 | 0.0169364 | 0.000261717 | 0.000971367
3025503 | Nivel 2 | 0.0408049 | 0.000261722 | 0.00234031
3025504 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025505 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025506 | Nivel 2 | 0.631374 | 0.000261727 | 0.0362116
3025507 | Nivel 2 | 0.1465 | 0.000261727 | 0.00840232
3025508 | Nivel 2 | 1.06711 | 0.000261727 | 0.0612025
3025509 | Nivel 2 | 0.0142587 | 0.000261727 | 0.000817789
3025513 | Nivel 2 | 0.824569 | 0.000261727 | 0.0472921
3025514 | Nivel 2 | 0.767057 | 0.000261727 | 0.0439936
3025517 | Nivel 2 | 2.1564 | 0.000261727 | 0.123678
3025518 | Nivel 2 | 0.216402 | 0.000261727 | 0.0124114
3025521 | Nivel 2 | 0.71239 | 0.000261717 | 0.0408582
3025522 | Nivel 2 | 0.941552 | 0.000261727 | 0.0540015
3025523 | Nivel 2 | 2.74157 | 0.000261717 | 0.157239
3025524 | Nivel 2 | 1.40806 | 0.000261727 | 0.0807573
3025525 | Nivel 2 | 0.589 | 0.000261727 | 0.0337813
3025526 | Nivel 2 | 0.43414 | 0.000261727 | 0.0248995
3025527 | Nivel 2 | 0.0103879 | 0.000261727 | 0.000595785
3025528 | Nivel 2 | 0.365602 | 0.000261727 | 0.0209686
3025529 | Nivel 2 | 0.0338912 | 0.000261727 | 0.00194379
3025530 | Nivel 2 | 1.11391 | 0.000261727 | 0.063887
3025533 | Nivel 2 | 0.310436 | 0.000261727 | 0.0178046
3025534 | Nivel 2 | 0.187113 | 0.000261727 | 0.0107316
3025535 | Nivel 2 | 0.0523645 | 0.000261727 | 0.0030033
3025538 | Nivel 2 | 1.8475 | 0.000261727 | 0.105961
3025542 | Nivel 2 | 0.4481 | 0.000261727 | 0.0257002
3025543 | Nivel 2 | 0.391107 | 0.000261727 | 0.0224314
3025544 | Nivel 2 | 0.241107 | 0.000261727 | 0.0138284
3025545 | Nivel 2 | 0.767057 | 0.000261727 | 0.0439936
3025546 | Nivel 2 | 3.49886 | 0.000261727 | 0.200672
3025547 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025550 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025552 | Nivel 2 | 1.90457 | 0.000261727 | 0.109234
3025553 | Nivel 2 | 1.8555 | 0.000261727 | 0.10642
3025554 | Nivel 2 | 1.22362 | 0.000261727 | 0.0701791
3025555 | Nivel 2 | 0.0124377 | 0.000261727 | 0.000713349
3025556 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025557 | Nivel 2 | 0.171257 | 0.000261727 | 0.00982222
3025562 | Nivel 2 | 0.0169369 | 0.000261727 | 0.000971391
3025563 | Nivel 2 | 0.258138 | 0.000261727 | 0.0148052
3025566 | Nivel 2 | 0.188638 | 0.000261727 | 0.0108191
3025569 | Nivel 2 | 0.657257 | 0.000261727 | 0.0376961
3025570 | Nivel 2 | 0.092445 | 0.000261717 | 0.00530206
3025573 | Nivel 2 | 0.0968611 | 0.000261727 | 0.00555534
3025574 | Nivel 2 | 0.182857 | 0.000261727 | 0.0104875
3025578 | Nivel 2 | 0.158503 | 0.000261727 | 0.00909073
3025581 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025582 | Nivel 2 | 0.085 | 0.000261727 | 0.00487506
3025585 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025588 | Nivel 2 | 0.0334442 | 0.000261727 | 0.00191815
3025595 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025596 | Nivel 2 | 0.0234188 | 0.000261727 | 0.00134315
3025599 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025602 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025603 | Nivel 2 | 0.0234188 | 0.000261727 | 0.00134315
3025606 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025609 | Nivel 2 | 0.14887 | 0.000261727 | 0.00853825
3025614 | Nivel 2 | 1.74696 | 0.000261727 | 0.100195
3025621 | Nivel 2 | 0.254567 | 0.000261727 | 0.0146003
3025622 | Nivel 2 | 1.548 | 0.000261727 | 0.0887836
3025623 | Nivel 2 | 0.645457 | 0.000261727 | 0.0370193
3025624 | Nivel 2 | 1.0355 | 0.000261727 | 0.0593897
3025625 | Nivel 2 | 0.2855 | 0.000261727 | 0.0163745
3025655 | Nivel 2 | 0.278619 | 0.000261727 | 0.0159798
3025656 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025657 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025658 | Nivel 2 | 0.027438 | 0.000261727 | 0.00157367
3025659 | Nivel 2 | 1.15457 | 0.000261717 | 0.0662188
3025660 | Nivel 2 | 0.804568 | 0.000261727 | 0.046145
3025661 | Nivel 2 | 0.804568 | 0.000261727 | 0.046145
3025662 | Nivel 2 | 2.56284 | 0.000261717 | 0.146988
3025664 | Nivel 2 | 1.8555 | 0.000261727 | 0.10642
3025665 | Nivel 2 | 0.615816 | 0.000261727 | 0.0353193
3025667 | Nivel 2 | 1.048 | 0.000261727 | 0.0601068
3025668 | Nivel 2 | 0.448 | 0.000261727 | 0.0256945
3025669 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025670 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025672 | Nivel 2 | 0.653897 | 0.000261727 | 0.0375034
3025673 | Nivel 2 | 1.51705 | 0.000261727 | 0.0870082
3025674 | Nivel 2 | 0.441527 | 0.000261717 | 0.0253232
3025676 | Nivel 2 | 0.998002 | 0.000261717 | 0.0572391
3025677 | Nivel 2 | 0.102603 | 0.000261727 | 0.00588469
3025678 | Nivel 2 | 0.0129369 | 0.000261717 | 0.000741977
3025679 | Nivel 2 | 0.0408183 | 0.000261727 | 0.00234108
3025680 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025681 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025682 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025683 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025684 | Nivel 2 | 0.0142642 | 0.000261727 | 0.000818107
3025688 | Nivel 2 | 0.824569 | 0.000261727 | 0.0472921
3025689 | Nivel 2 | 0.7555 | 0.000261727 | 0.0433307
3025692 | Nivel 2 | 2.1564 | 0.000261727 | 0.123678
3025693 | Nivel 2 | 0.216402 | 0.000261727 | 0.0124114
3025696 | Nivel 2 | 0.18442 | 0.000261727 | 0.0105772
3025697 | Nivel 2 | 0.941552 | 0.000261727 | 0.0540015
3025698 | Nivel 2 | 2.69157 | 0.000261727 | 0.154372
3025699 | Nivel 2 | 1.40806 | 0.000261727 | 0.0807573
3025700 | Nivel 2 | 0.589 | 0.000261727 | 0.0337813
3025701 | Nivel 2 | 0.429721 | 0.000261727 | 0.0246461
3025702 | Nivel 2 | 0.362602 | 0.000261727 | 0.0207966
3025703 | Nivel 2 | 0.0188879 | 0.000261727 | 0.00108329
3025706 | Nivel 2 | 1.10236 | 0.000261727 | 0.0632243
3025709 | Nivel 2 | 0.431477 | 0.000261727 | 0.0247468
3025710 | Nivel 2 | 0.243258 | 0.000261727 | 0.0139517
3025713 | Nivel 2 | 1.8475 | 0.000261727 | 0.105961
3025716 | Nivel 2 | 1.548 | 0.000261727 | 0.0887836
3025718 | Nivel 2 | 0.4481 | 0.000261727 | 0.0257002
3025719 | Nivel 2 | 0.391107 | 0.000261727 | 0.0224314
3025720 | Nivel 2 | 0.241107 | 0.000261727 | 0.0138284
3025721 | Nivel 2 | 0.7555 | 0.000261727 | 0.0433307
3025722 | Nivel 2 | 3.49886 | 0.000261727 | 0.200672
3025723 | Nivel 2 | 0.217057 | 0.000261727 | 0.012449
3025727 | Nivel 2 | 1.90457 | 0.000261727 | 0.109234
3025728 | Nivel 2 | 1.8555 | 0.000261727 | 0.10642
3025729 | Nivel 2 | 1.10942 | 0.000261717 | 0.0636293
3025730 | Nivel 2 | 0.017438 | 0.000261727 | 0.00100014
3025731 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3025732 | Nivel 2 | 0.208769 | 0.000261727 | 0.0119737
3025737 | Nivel 2 | 0.704326 | 0.000261727 | 0.0403957
3025738 | Nivel 2 | 0.193638 | 0.000261727 | 0.0111059
3025739 | Nivel 2 | 0.657257 | 0.000261717 | 0.0376961
3025740 | Nivel 2 | 0.102445 | 0.000261727 | 0.0058756
3025741 | Nivel 2 | 0.0893379 | 0.000261727 | 0.00512386
3025744 | Nivel 2 | 0.182857 | 0.000261727 | 0.0104875
3025746 | Nivel 2 | 0.158503 | 0.000261727 | 0.00909073
3025749 | Nivel 2 | 0.202181 | 0.000261727 | 0.0115958
3025750 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025751 | Nivel 2 | 0.075 | 0.000261727 | 0.00430153
3025754 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025757 | Nivel 2 | 0.571415 | 0.000261727 | 0.0327727
3025764 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025765 | Nivel 2 | 0.0234188 | 0.000261727 | 0.00134315
3025768 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025771 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025772 | Nivel 2 | 0.0234188 | 0.000261727 | 0.00134315
3025775 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025778 | Nivel 2 | 0.14887 | 0.000261727 | 0.00853825
3025783 | Nivel 2 | 1.75852 | 0.000261727 | 0.100858
3025787 | Nivel 2 | 0.286521 | 0.000261727 | 0.0164331
3025788 | Nivel 2 | 0.6963 | 0.000261727 | 0.0399354
3025794 | Nivel 2 | 1.11439 | 0.000445281 | 0.0833666
3025795 | Nivel 2 | 0.00675666 | 0.000445281 | 0.00050546
3025796 | Nivel 2 | 1.23982 | 0.000445281 | 0.0927499
3025797 | Nivel 2 | 6.573 | 0.000445281 | 0.491721
3025798 | Nivel 2 | 0.1985 | 0.000445265 | 0.0148496
3025799 | Nivel 2 | 0.2055 | 0.000445281 | 0.0153733
3025800 | Nivel 2 | 0.599014 | 0.000445281 | 0.0448118
3025801 | Nivel 2 | 3.25912 | 0.000445281 | 0.243812
3025802 | Nivel 2 | 1.9333 | 0.000261727 | 0.110882
3025803 | Nivel 2 | 0.424815 | 0.000261727 | 0.0243647
3025806 | Nivel 2 | 0.00269577 | 0.000445281 | 0.000201668
3025807 | Nivel 2 | 0.0179324 | 0.000445281 | 0.00134151
3025810 | Nivel 2 | 0.00269577 | 0.000445281 | 0.000201668
3025813 | Nivel 2 | 2.23222 | 0.000445281 | 0.16699
3025822 | Nivel 2 | 0.0115765 | 0.000261727 | 0.000663952
3025823 | Nivel 2 | 0.2 | 0.000261727 | 0.0114707
3025826 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025829 | Nivel 2 | 0.017729 | 0.000261727 | 0.00101682
3025832 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025833 | Nivel 2 | 0.0179324 | 0.000261727 | 0.00102849
3025836 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3025839 | Nivel 2 | 0.291829 | 0.000261727 | 0.0167375
3025849 | Nivel 2 | 0.241091 | 0.000261727 | 0.0138274
3025850 | Nivel 2 | 1.35873 | 0.000261727 | 0.0779281
3025861 | Nivel 2 | 0.0387593 | 0.000261727 | 0.00222299
3025862 | Nivel 2 | 0.947858 | 0.000261727 | 0.0543631
3025864 | Nivel 2 | 0.0509781 | 0.000261727 | 0.00292378
3025865 | Nivel 2 | 0.0996307 | 0.000261727 | 0.00571419
3025868 | Nivel 2 | 0.33634 | 0.000261727 | 0.0192903
3025871 | Nivel 2 | 0.0996307 | 0.000261727 | 0.00571419
3025876 | Nivel 2 | 0.444809 | 0.000261727 | 0.0255115
3025878 | Nivel 2 | 0.0387586 | 0.000261727 | 0.00222295
3025879 | Nivel 2 | 0.947857 | 0.000261727 | 0.0543631
3025881 | Nivel 2 | 0.0509781 | 0.000261727 | 0.00292378
3025882 | Nivel 2 | 0.0996307 | 0.000261727 | 0.00571419
3025885 | Nivel 2 | 0.33634 | 0.000261727 | 0.0192903
3025888 | Nivel 2 | 0.0996307 | 0.000261727 | 0.00571419
3025893 | Nivel 2 | 0.444809 | 0.000261727 | 0.0255115
3025896 | Nivel 2 | 0.0387586 | 0.000261727 | 0.00222295
3025897 | Nivel 2 | 0.947857 | 0.000261727 | 0.0543631
3025898 | Nivel 2 | 0.0509781 | 0.000261727 | 0.00292378
3025899 | Nivel 2 | 0.0996307 | 0.000261727 | 0.00571419
3025902 | Nivel 2 | 0.33634 | 0.000261727 | 0.0192903
3025905 | Nivel 2 | 0.0996307 | 0.000261727 | 0.00571419
3025910 | Nivel 2 | 0.444809 | 0.000261727 | 0.0255115
3025912 | Nivel 2 | 0.0387593 | 0.000261727 | 0.00222299
3025913 | Nivel 2 | 0.947858 | 0.000261727 | 0.0543631
3025915 | Nivel 2 | 0.0509781 | 0.000261727 | 0.00292378
3025916 | Nivel 2 | 0.0996307 | 0.000261727 | 0.00571419
3025919 | Nivel 2 | 0.33634 | 0.000261727 | 0.0192903
3025922 | Nivel 2 | 0.0996307 | 0.000261727 | 0.00571419
3025927 | Nivel 2 | 0.444809 | 0.000261727 | 0.0255115
3025930 | Nivel 2 | 0.464617 | 0.000261727 | 0.0266475
3025933 | Nivel 2 | 0.502215 | 0.000261727 | 0.0288039
3025936 | Nivel 2 | 0.492204 | 0.000261727 | 0.0282297
3025939 | Nivel 2 | 0.502201 | 0.000261727 | 0.0288031
3025953 | Nivel 2 | 0.0118369 | 0.000261727 | 0.000678892
3025954 | Nivel 2 | 2.04169 | 0.000261727 | 0.117099
3025963 | Nivel 2 | 0.0119369 | 0.000261727 | 0.000684623
3025970 | Nivel 2 | 0.706826 | 0.000261727 | 0.0405391
3025973 | Nivel 2 | 0.743669 | 0.000261727 | 0.0426522
3025974 | Nivel 2 | 0.0119369 | 0.000261727 | 0.000684623
3025981 | Nivel 2 | 0.767057 | 0.000261727 | 0.0439936
3025986 | Nivel 2 | 0.00783803 | 0.000261727 | 0.00044954
3025987 | Nivel 2 | 0.250638 | 0.000261727 | 0.014375
3025992 | Nivel 2 | 0.0130309 | 0.000261727 | 0.000747368
3025995 | Nivel 2 | 0.0111381 | 0.000261727 | 0.000638809
3025996 | Nivel 2 | 0.631374 | 0.000261727 | 0.0362116
3026023 | Nivel 2 | 0.0303379 | 0.000261727 | 0.00173999
3026029 | Nivel 2 | 0.636683 | 0.000261727 | 0.0365161
3026030 | Nivel 2 | 0.030338 | 0.000261727 | 0.00174
3026037 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3026038 | Nivel 2 | 0.125 | 0.000261727 | 0.00716921
3026041 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3026044 | Nivel 2 | 0.0399794 | 0.000261727 | 0.00229297
3026055 | Nivel 2 | 0.952057 | 0.000261727 | 0.054604
3026066 | Nivel 2 | 1.59457 | 0.000261727 | 0.0914544
3026072 | Nivel 2 | 0.188638 | 0.000261727 | 0.0108191
3026075 | Nivel 2 | 0.360934 | 0.000261727 | 0.0207009
3026078 | Nivel 2 | 0.0228375 | 0.000261717 | 0.00130982
3026082 | Nivel 2 | 2.04172 | 0.000261727 | 0.1171
3026092 | Nivel 2 | 0.0129394 | 0.000261727 | 0.000742123
3026093 | Nivel 2 | 0.743602 | 0.000261727 | 0.0426483
3026103 | Nivel 2 | 0.0129353 | 0.000261717 | 0.000741885
3026110 | Nivel 2 | 0.767057 | 0.000261727 | 0.0439936
3026115 | Nivel 2 | 0.0128395 | 0.000261727 | 0.000736393
3026119 | Nivel 2 | 0.048 | 0.000261727 | 0.00275298
3026123 | Nivel 2 | 0.755503 | 0.000261727 | 0.0433309
3026124 | Nivel 2 | 0.80457 | 0.000261727 | 0.0461451
3026129 | Nivel 2 | 0.253138 | 0.000261727 | 0.0145184
3026137 | Nivel 2 | 0.0130309 | 0.000261727 | 0.000747368
3026152 | Nivel 2 | 0.0261415 | 0.000261727 | 0.00149931
3026153 | Nivel 2 | 0.631373 | 0.000261727 | 0.0362116
3026162 | Nivel 2 | 0.254571 | 0.000261727 | 0.0146006
3026163 | Nivel 2 | 0.21706 | 0.000261727 | 0.0124492
3026164 | Nivel 2 | 0.0303402 | 0.000261727 | 0.00174012
3026165 | Nivel 2 | 0.636683 | 0.000261727 | 0.0365161
3026166 | Nivel 2 | 0.0303369 | 0.000261727 | 0.00173993
3026167 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3026168 | Nivel 2 | 0.125 | 0.000261727 | 0.00716921
3026171 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3026174 | Nivel 2 | 0.0399794 | 0.000261727 | 0.00229297
3026196 | Nivel 2 | 0.00788792 | 0.000261727 | 0.000452401
3026197 | Nivel 2 | 0.193138 | 0.000261727 | 0.0110772
3026209 | Nivel 2 | 1.06711 | 0.000261727 | 0.0612025
3026211 | Nivel 2 | 1.59457 | 0.000261727 | 0.0914544
3026217 | Nivel 2 | 1.04707 | 0.000261727 | 0.0600531
3026218 | Nivel 2 | 1.03611 | 0.000261727 | 0.0594246
3026219 | Nivel 2 | 0.27545 | 0.000261727 | 0.0157981
3026220 | Nivel 2 | 3.2319 | 0.000261727 | 0.185361
3026227 | Nivel 2 | 0.0168252 | 0.000261727 | 0.000964988
3026228 | Nivel 2 | 2.04171 | 0.000261727 | 0.1171
3026242 | Nivel 2 | 0.699326 | 0.000261727 | 0.0401089
3026243 | Nivel 2 | 0.743652 | 0.000261727 | 0.0426512
3026248 | Nivel 2 | 0.0169369 | 0.000261727 | 0.000971391
3026251 | Nivel 2 | 0.804569 | 0.000261727 | 0.046145
3026252 | Nivel 2 | 0.804569 | 0.000261717 | 0.046145
3026257 | Nivel 2 | 0.767057 | 0.000261727 | 0.0439936
3026264 | Nivel 2 | 0.00783877 | 0.000261727 | 0.000449583
3026275 | Nivel 2 | 0.048 | 0.000261727 | 0.00275298
3026283 | Nivel 2 | 0.0205541 | 0.000261727 | 0.00117885
3026298 | Nivel 2 | 0.0161354 | 0.000261727 | 0.000925423
3026307 | Nivel 2 | 0.254571 | 0.000261727 | 0.0146006
3026308 | Nivel 2 | 0.0303402 | 0.000261727 | 0.00174012
3026309 | Nivel 2 | 0.636683 | 0.000261727 | 0.0365161
3026310 | Nivel 2 | 0.0301287 | 0.000261727 | 0.00172799
3026311 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3026312 | Nivel 2 | 0.125 | 0.000261727 | 0.00716921
3026315 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3026318 | Nivel 2 | 0.0399794 | 0.000261727 | 0.00229297
3026336 | Nivel 2 | 0.204391 | 0.000261727 | 0.0117226
3026345 | Nivel 2 | 1.59457 | 0.000261727 | 0.0914544
3026346 | Nivel 2 | 0.196942 | 0.000261727 | 0.0112954
3026357 | Nivel 2 | 0.0183334 | 0.000261727 | 0.00105149
3026358 | Nivel 2 | 2.04219 | 0.000261727 | 0.117127
3026372 | Nivel 2 | 0.684326 | 0.000261727 | 0.0392486
3026375 | Nivel 2 | 0.743669 | 0.000261727 | 0.0426522
3026382 | Nivel 2 | 0.0229379 | 0.000261727 | 0.00131557
3026390 | Nivel 2 | 0.021137 | 0.000261727 | 0.00121229
3026406 | Nivel 2 | 0.00803087 | 0.000261727 | 0.0004606
3026427 | Nivel 2 | 0.048 | 0.000261727 | 0.00275298
3026428 | Nivel 2 | 0.00836907 | 0.000261727 | 0.000479997
3026435 | Nivel 2 | 0.767057 | 0.000261727 | 0.0439936
3026440 | Nivel 2 | 0.254569 | 0.000261727 | 0.0146005
3026441 | Nivel 2 | 0.0303379 | 0.000261727 | 0.00173999
3026442 | Nivel 2 | 0.636683 | 0.000261727 | 0.0365161
3026443 | Nivel 2 | 0.0301411 | 0.000261727 | 0.0017287
3026444 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3026445 | Nivel 2 | 0.125 | 0.000261727 | 0.00716921
3026448 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3026451 | Nivel 2 | 0.0399794 | 0.000261727 | 0.00229297
3026467 | Nivel 2 | 0.188638 | 0.000261727 | 0.0108191
3026477 | Nivel 2 | 1.06711 | 0.000261727 | 0.0612025
3026479 | Nivel 2 | 1.59457 | 0.000261727 | 0.0914544
3026485 | Nivel 2 | 0.285509 | 0.000261727 | 0.016375
3026490 | Nivel 2 | 1.04706 | 0.000261727 | 0.0600526
3026493 | Nivel 2 | 2.84962 | 0.000261727 | 0.163436
3026494 | Nivel 2 | 2.87235 | 0.000261727 | 0.16474
3026495 | Nivel 2 | 2.84568 | 0.000445281 | 0.212883
3026496 | Nivel 2 | 0.258057 | 0.000261727 | 0.0148005
3026497 | Nivel 2 | 0.258057 | 0.000261727 | 0.0148005
3026498 | Nivel 2 | 0.25285 | 0.000445281 | 0.0189155
3026499 | Nivel 2 | 0.269062 | 0.000445281 | 0.0201283
3026500 | Nivel 2 | 0.244596 | 0.000261727 | 0.0140285
3026501 | Nivel 2 | 0.214512 | 0.000261727 | 0.0123031
3026502 | Nivel 2 | 0.0255161 | 0.000445281 | 0.00190884
3026503 | Nivel 2 | 0.273143 | 0.000445281 | 0.0204336
3026506 | Nivel 2 | 0.0255161 | 0.000445281 | 0.00190884
3026509 | Nivel 2 | 0.0531472 | 0.000445281 | 0.0039759
3026514 | Nivel 2 | 0.05832 | 0.000261727 | 0.00334487
3026515 | Nivel 2 | 0.0277886 | 0.000261727 | 0.00159378
3026516 | Nivel 2 | 0.0751356 | 0.000261727 | 0.0043093
3026519 | Nivel 2 | 0.0277886 | 0.000261727 | 0.00159378
3026526 | Nivel 2 | 0.0115765 | 0.000261727 | 0.000663952
3026527 | Nivel 2 | 3.3027 | 0.000261727 | 0.189422
3026528 | Nivel 2 | 0.0125953 | 0.000445281 | 0.000942241
3026529 | Nivel 2 | 0.0277886 | 0.000261727 | 0.00159378
3026530 | Nivel 2 | 0.195169 | 0.000261727 | 0.0111936
3026539 | Nivel 2 | 0.0115765 | 0.000261727 | 0.000663952
3026540 | Nivel 2 | 0.0277886 | 0.000261727 | 0.00159378
3026541 | Nivel 2 | 0.195169 | 0.000261727 | 0.0111936
3026546 | Nivel 2 | 1.15372 | 0.000261727 | 0.0661699
3026557 | Nivel 2 | 0.0288274 | 0.000445281 | 0.00215656
3026558 | Nivel 2 | 0.192491 | 0.000445281 | 0.0144001
3026577 | Nivel 2 | 0.0315074 | 0.000261727 | 0.00180706
3026578 | Nivel 2 | 0.695638 | 0.000261727 | 0.0398974
3026581 | Nivel 2 | 0.356826 | 0.000261727 | 0.0204653
3026586 | Nivel 2 | 0.0314726 | 0.000261727 | 0.00180507
3026587 | Nivel 2 | 0.695638 | 0.000261727 | 0.0398974
3026588 | Nivel 2 | 0.356923 | 0.000261727 | 0.0204708
3026597 | Nivel 2 | 0.0316382 | 0.000261727 | 0.00181457
3026598 | Nivel 2 | 0.695638 | 0.000261727 | 0.0398974
3026599 | Nivel 2 | 0.356495 | 0.000261727 | 0.0204463
3026602 | Nivel 2 | 0.0315588 | 0.000261727 | 0.00181001
3026603 | Nivel 2 | 0.695638 | 0.000261727 | 0.0398974
3026604 | Nivel 2 | 0.356436 | 0.000261727 | 0.0204429
3026619 | Nivel 2 | 0.279532 | 0.000261727 | 0.0160322
3026620 | Nivel 2 | 0.0475876 | 0.000261727 | 0.00272933
3026621 | Nivel 2 | 0.0363541 | 0.000261727 | 0.00208504
3026630 | Nivel 2 | 0.250299 | 0.000261727 | 0.0143556
3026631 | Nivel 2 | 0.0475876 | 0.000261727 | 0.00272933
3026632 | Nivel 2 | 0.0771443 | 0.000261727 | 0.00442451
3026641 | Nivel 2 | 0.269295 | 0.000261727 | 0.0154451
3026642 | Nivel 2 | 0.0475876 | 0.000261727 | 0.00272933
3026643 | Nivel 2 | 0.0581536 | 0.000261727 | 0.00333532
3026650 | Nivel 2 | 0.15765 | 0.000261727 | 0.00904183
3026651 | Nivel 2 | 0.0490018 | 0.000261727 | 0.00281044
3026652 | Nivel 2 | 0.081437 | 0.000261727 | 0.00467071
3026659 | Nivel 2 | 0.817376 | 0.000261717 | 0.0468795
3026660 | Nivel 2 | 0.0045054 | 0.000261727 | 0.000258402
3026661 | Nivel 2 | 0.455819 | 0.000261727 | 0.0261429
3026670 | Nivel 2 | 0.221123 | 0.000261727 | 0.0126822
3026671 | Nivel 2 | 0.0242115 | 0.000261727 | 0.00138862
3026672 | Nivel 2 | 0.330327 | 0.000261727 | 0.0189455
3026675 | Nivel 2 | 0.024215 | 0.000261727 | 0.00138882
3026678 | Nivel 2 | 0.680212 | 0.000261727 | 0.0390127
3026687 | Nivel 2 | 0.514375 | 0.000261717 | 0.0295013
3026688 | Nivel 2 | 0.0419308 | 0.000261727 | 0.00240488
3026689 | Nivel 2 | 0.184076 | 0.000261727 | 0.0105574
3026692 | Nivel 2 | 0.0724778 | 0.000261727 | 0.00415687
3026695 | Nivel 2 | 0.556051 | 0.000261727 | 0.0318916
3026704 | Nivel 2 | 0.538454 | 0.000261727 | 0.0308823
3026705 | Nivel 2 | 0.00450551 | 0.000261727 | 0.000258408
3026706 | Nivel 2 | 0.0825002 | 0.000261727 | 0.00473169
3026709 | Nivel 2 | 0.0327894 | 0.000261727 | 0.0018806
3026712 | Nivel 2 | 0.602073 | 0.000261727 | 0.0345311
3026721 | Nivel 2 | 0.737436 | 0.000261727 | 0.0422947
3026722 | Nivel 2 | 0.0101622 | 0.000261727 | 0.000582842
3026723 | Nivel 2 | 0.05 | 0.000261727 | 0.00286769
3026726 | Nivel 2 | 0.0101622 | 0.000261727 | 0.000582842
3026729 | Nivel 2 | 0.264814 | 0.000261727 | 0.0151881
3026740 | Nivel 2 | 0.737436 | 0.000261717 | 0.0422947
3026741 | Nivel 2 | 0.0101622 | 0.000261727 | 0.000582842
3026742 | Nivel 2 | 0.05 | 0.000261727 | 0.00286769
3026745 | Nivel 2 | 0.0101622 | 0.000261727 | 0.000582842
3026748 | Nivel 2 | 0.264814 | 0.000261727 | 0.0151881
3026757 | Nivel 2 | 0.253257 | 0.000261727 | 0.0145253
3026758 | Nivel 2 | 0.0101622 | 0.000261727 | 0.000582842
3026759 | Nivel 2 | 0.05 | 0.000261727 | 0.00286769
3026762 | Nivel 2 | 0.0101622 | 0.000261727 | 0.000582842
3026765 | Nivel 2 | 0.737436 | 0.000261727 | 0.0422947
3026774 | Nivel 2 | 0.0219966 | 0.000261727 | 0.00126159
3026775 | Nivel 2 | 1.07863 | 0.000261727 | 0.0618632
3026778 | Nivel 2 | 0.836436 | 0.000261727 | 0.0479727
3026781 | Nivel 2 | 0.163814 | 0.000261727 | 0.00939536
3026782 | Nivel 2 | 0.0115765 | 0.000261727 | 0.000663952
3026783 | Nivel 2 | 0.05 | 0.000261727 | 0.00286769
3026786 | Nivel 2 | 0.0115765 | 0.000261727 | 0.000663952
3026797 | Nivel 2 | 0.685939 | 0.000261727 | 0.0393411
3026798 | Nivel 2 | 0.00450199 | 0.000261727 | 0.000258206
3026799 | Nivel 2 | 0.0499976 | 0.000261727 | 0.00286755
3026802 | Nivel 2 | 0.00450368 | 0.000261727 | 0.000258303
3026805 | Nivel 2 | 0.0573411 | 0.000261727 | 0.00328872
3026812 | Nivel 2 | 0.686053 | 0.000261727 | 0.0393477
3026813 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3026814 | Nivel 2 | 0.05 | 0.000261727 | 0.00286769
3026817 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3026820 | Nivel 2 | 0.0455759 | 0.000261717 | 0.00261395
3026829 | Nivel 2 | 0.0480437 | 0.000261727 | 0.00275549
3026830 | Nivel 2 | 0.00450392 | 0.000261727 | 0.000258316
3026831 | Nivel 2 | 0.0499979 | 0.000261727 | 0.00286757
3026834 | Nivel 2 | 0.0045024 | 0.000261727 | 0.000258229
3026837 | Nivel 2 | 0.675021 | 0.000261727 | 0.038715
3026846 | Nivel 2 | 0.0518201 | 0.000261727 | 0.00297207
3026847 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3026848 | Nivel 2 | 0.05 | 0.000261727 | 0.00286769
3026851 | Nivel 2 | 0.00450538 | 0.000261727 | 0.0002584
3026854 | Nivel 2 | 0.68655 | 0.000261727 | 0.0393762
3026863 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026864 | Nivel 2 | 0.175 | 0.000261727 | 0.0100369
3026867 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026870 | Nivel 2 | 0.0611205 | 0.000261727 | 0.00350548
3026871 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026872 | Nivel 2 | 0.175 | 0.000261727 | 0.0100369
3026875 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026878 | Nivel 2 | 0.0611205 | 0.000261727 | 0.00350548
3026891 | Nivel 2 | 0.0483648 | 0.000261727 | 0.0027739
3026892 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026893 | Nivel 2 | 0.14625 | 0.000261727 | 0.00838798
3026896 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026899 | Nivel 2 | 0.757407 | 0.000261727 | 0.0434401
3026900 | Nivel 2 | 0.0483648 | 0.000261727 | 0.0027739
3026901 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026902 | Nivel 2 | 0.14625 | 0.000261727 | 0.00838798
3026905 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026908 | Nivel 2 | 1.17889 | 0.000261727 | 0.0676139
3026925 | Nivel 2 | 1.17815 | 0.000261727 | 0.0675715
3026926 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026927 | Nivel 2 | 0.145 | 0.000261727 | 0.00831629
3026930 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026933 | Nivel 2 | 0.061911 | 0.000261727 | 0.00355082
3026934 | Nivel 2 | 0.756668 | 0.000261727 | 0.0433977
3026935 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026936 | Nivel 2 | 0.145 | 0.000261727 | 0.00831629
3026939 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026942 | Nivel 2 | 0.061911 | 0.000261727 | 0.00355082
3026957 | Nivel 2 | 0.0433648 | 0.000261727 | 0.00248713
3026958 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026959 | Nivel 2 | 0.1675 | 0.000261727 | 0.00960674
3026962 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026965 | Nivel 2 | 0.741157 | 0.000261727 | 0.0425081
3026966 | Nivel 2 | 0.0433648 | 0.000261727 | 0.00248713
3026967 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026968 | Nivel 2 | 0.1675 | 0.000261727 | 0.00960674
3026971 | Nivel 2 | 0.0327897 | 0.000261727 | 0.00188061
3026974 | Nivel 2 | 1.16264 | 0.000261727 | 0.0666819
3026993 | Nivel 2 | 0.774569 | 0.000261727 | 0.0444244
3026998 | Nivel 2 | 0.0752445 | 0.000261727 | 0.00431555
3026999 | Nivel 2 | 1.36611 | 0.000261727 | 0.0783517
3027002 | Nivel 2 | 1.13386 | 0.000261727 | 0.065031
3027007 | Nivel 2 | 0.774569 | 0.000261727 | 0.0444244
3027012 | Nivel 2 | 0.075193 | 0.000261727 | 0.0043126
3027013 | Nivel 2 | 1.36536 | 0.000261727 | 0.0783087
3027016 | Nivel 2 | 0.754569 | 0.000261727 | 0.0432773
3027021 | Nivel 2 | 0.073057 | 0.000261727 | 0.00419009
3027022 | Nivel 2 | 1.36611 | 0.000261727 | 0.0783517
3027025 | Nivel 2 | 1.13386 | 0.000261727 | 0.065031
3027030 | Nivel 2 | 0.774569 | 0.000261727 | 0.0444244
3027037 | Nivel 2 | 0.0756929 | 0.000261727 | 0.00434127
3027038 | Nivel 2 | 1.36531 | 0.000261727 | 0.0783058
3027041 | Nivel 2 | 1.13386 | 0.000261727 | 0.065031
3027044 | Nivel 2 | 1.13386 | 0.000261727 | 0.065031
3031117 | Level 4 | 0.279115 | 0.000261727 | 0.0160083
3031118 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031119 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031120 | Level 4 | 0.0229341 | 0.000261727 | 0.00131535
3031121 | Level 4 | 1.15457 | 0.000261727 | 0.0662188
3031122 | Level 4 | 0.804569 | 0.000261727 | 0.046145
3031123 | Level 4 | 0.804569 | 0.000261727 | 0.046145
3031124 | Level 4 | 2.51533 | 0.000261717 | 0.144263
3031126 | Level 4 | 1.8555 | 0.000261727 | 0.10642
3031127 | Level 4 | 0.615816 | 0.000261727 | 0.0353193
3031129 | Level 4 | 0.998002 | 0.000261727 | 0.0572391
3031130 | Level 4 | 0.448 | 0.000261727 | 0.0256945
3031131 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031132 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031134 | Level 4 | 0.668585 | 0.000261727 | 0.0383458
3031135 | Level 4 | 1.51706 | 0.000261727 | 0.0870088
3031136 | Level 4 | 0.441527 | 0.000261727 | 0.0253232
3031138 | Level 4 | 1.048 | 0.000261727 | 0.0601068
3031139 | Level 4 | 0.1026 | 0.000261727 | 0.00588449
3031140 | Level 4 | 0.7926 | 0.000261727 | 0.0454585
3031141 | Level 4 | 0.767057 | 0.000261727 | 0.0439936
3031142 | Level 4 | 0.296722 | 0.000261727 | 0.0170181
3031143 | Level 4 | 0.0229379 | 0.000261727 | 0.00131557
3031144 | Level 4 | 0.0408 | 0.000261727 | 0.00234003
3031145 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031146 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031147 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031148 | Level 4 | 0.631383 | 0.000261727 | 0.0362121
3031149 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031150 | Level 4 | 0.0142587 | 0.000261727 | 0.000817789
3031155 | Level 4 | 0.804569 | 0.000261727 | 0.046145
3031156 | Level 4 | 0.767057 | 0.000261727 | 0.0439936
3031159 | Level 4 | 2.1564 | 0.000261727 | 0.123678
3031160 | Level 4 | 0.166402 | 0.000261727 | 0.00954375
3031163 | Level 4 | 0.17942 | 0.000261727 | 0.0102904
3031164 | Level 4 | 0.941555 | 0.000261727 | 0.0540017
3031165 | Level 4 | 2.69157 | 0.000261727 | 0.154372
3031166 | Level 4 | 1.3965 | 0.000261727 | 0.0800944
3031167 | Level 4 | 0.589 | 0.000261727 | 0.0337813
3031168 | Level 4 | 0.403493 | 0.000261717 | 0.0231418
3031169 | Level 4 | 0.012888 | 0.000261727 | 0.000739177
3031170 | Level 4 | 0.368727 | 0.000261727 | 0.0211479
3031171 | Level 4 | 0.0131379 | 0.000261727 | 0.000753508
3031172 | Level 4 | 1.11391 | 0.000261727 | 0.063887
3031175 | Level 4 | 0.324805 | 0.000261727 | 0.0186288
3031176 | Level 4 | 0.173109 | 0.000261727 | 0.00992845
3031177 | Level 4 | 0.0507798 | 0.000261727 | 0.00291241
3031178 | Level 4 | 1.8475 | 0.000261727 | 0.105961
3031180 | Level 4 | 1.548 | 0.000261727 | 0.0887836
3031182 | Level 4 | 0.4 | 0.000261727 | 0.0229415
3031183 | Level 4 | 0.391107 | 0.000261727 | 0.0224314
3031184 | Level 4 | 0.241107 | 0.000261727 | 0.0138284
3031185 | Level 4 | 0.767057 | 0.000261727 | 0.0439936
3031186 | Level 4 | 3.49886 | 0.000261727 | 0.200672
3031187 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031190 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031192 | Level 4 | 1.95457 | 0.000261727 | 0.112102
3031193 | Level 4 | 1.9055 | 0.000261727 | 0.109288
3031194 | Level 4 | 0.6355 | 0.000261727 | 0.0364483
3031195 | Level 4 | 1.09862 | 0.000261717 | 0.0630099
3031196 | Level 4 | 0.0174379 | 0.000261727 | 0.00100013
3031197 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031198 | Level 4 | 0.171257 | 0.000261727 | 0.00982222
3031203 | Level 4 | 0.0229379 | 0.000261727 | 0.00131557
3031204 | Level 4 | 0.273138 | 0.000261727 | 0.0156655
3031207 | Level 4 | 0.201138 | 0.000261727 | 0.011536
3031208 | Level 4 | 0.657257 | 0.000261727 | 0.0376961
3031211 | Level 4 | 0.097445 | 0.000261727 | 0.00558883
3031212 | Level 4 | 0.0843352 | 0.000261727 | 0.00483694
3031213 | Level 4 | 0.727458 | 0.000261727 | 0.0417224
3031214 | Level 4 | 0.182857 | 0.000261727 | 0.0104875
3031217 | Level 4 | 1.14894 | 0.000261727 | 0.0658962
3031219 | Level 4 | 0.158503 | 0.000261727 | 0.00909073
3031222 | Level 4 | 0.202183 | 0.000261727 | 0.011596
3031223 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031224 | Level 4 | 0.0875 | 0.000261727 | 0.00501845
3031227 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031230 | Level 4 | 0.563915 | 0.000261727 | 0.0323426
3031237 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031238 | Level 4 | 0.0234188 | 0.000261727 | 0.00134315
3031241 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031244 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031245 | Level 4 | 0.0234188 | 0.000261727 | 0.00134315
3031248 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031251 | Level 4 | 0.14887 | 0.000261727 | 0.00853825
3031256 | Level 4 | 1.75852 | 0.000261727 | 0.100858
3031285 | Level 4 | 0.278619 | 0.000261727 | 0.0159798
3031286 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031287 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031288 | Level 4 | 0.0164369 | 0.000261717 | 0.000942715
3031289 | Level 4 | 1.15457 | 0.000261727 | 0.0662188
3031290 | Level 4 | 0.804569 | 0.000261727 | 0.046145
3031291 | Level 4 | 0.804569 | 0.000261727 | 0.046145
3031292 | Level 4 | 2.52633 | 0.000261727 | 0.144894
3031294 | Level 4 | 1.8555 | 0.000261727 | 0.10642
3031295 | Level 4 | 0.615816 | 0.000261727 | 0.0353193
3031297 | Level 4 | 0.998002 | 0.000261727 | 0.0572391
3031298 | Level 4 | 0.448 | 0.000261727 | 0.0256945
3031299 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031300 | Level 4 | 0.2426 | 0.000261727 | 0.013914
3031302 | Level 4 | 0.66863 | 0.000261727 | 0.0383484
3031303 | Level 4 | 1.50553 | 0.000261727 | 0.0863477
3031304 | Level 4 | 0.42997 | 0.000261717 | 0.0246603
3031306 | Level 4 | 0.998002 | 0.000261727 | 0.0572391
3031307 | Level 4 | 0.048 | 0.000261727 | 0.00275298
3031308 | Level 4 | 0.1026 | 0.000261727 | 0.00588449
3031309 | Level 4 | 0.804569 | 0.000261717 | 0.046145
3031310 | Level 4 | 0.7555 | 0.000261727 | 0.0433307
3031311 | Level 4 | 0.296722 | 0.000261727 | 0.0170181
3031312 | Level 4 | 0.0408 | 0.000261727 | 0.00234003
3031313 | Level 4 | 0.254619 | 0.000261727 | 0.0146033
3031314 | Level 4 | 0.2055 | 0.000261727 | 0.0117862
3031315 | Level 4 | 0.2055 | 0.000261727 | 0.0117862
3031316 | Level 4 | 0.0142587 | 0.000261727 | 0.000817789
3031320 | Level 4 | 0.824569 | 0.000261727 | 0.0472921
3031321 | Level 4 | 0.7555 | 0.000261727 | 0.0433307
3031324 | Level 4 | 2.1564 | 0.000261727 | 0.123678
3031325 | Level 4 | 0.216402 | 0.000261727 | 0.0124114
3031328 | Level 4 | 0.679625 | 0.000261717 | 0.038979
3031329 | Level 4 | 0.941552 | 0.000261727 | 0.0540015
3031330 | Level 4 | 2.74157 | 0.000261717 | 0.157239
3031331 | Level 4 | 1.3965 | 0.000261727 | 0.0800944
3031332 | Level 4 | 0.589 | 0.000261727 | 0.0337813
3031333 | Level 4 | 0.405071 | 0.000261727 | 0.0232323
3031334 | Level 4 | 0.00571991 | 0.000261727 | 0.000328058
3031335 | Level 4 | 0.0175129 | 0.000261727 | 0.00100443
3031338 | Level 4 | 1.10235 | 0.000261727 | 0.0632241
3031341 | Level 4 | 0.443274 | 0.000261727 | 0.0254234
3031342 | Level 4 | 0.243454 | 0.000261727 | 0.013963
3031343 | Level 4 | 0.106348 | 0.000261727 | 0.00609945
3031344 | Level 4 | 1.8475 | 0.000261727 | 0.105961
3031348 | Level 4 | 0.4481 | 0.000261727 | 0.0257002
3031349 | Level 4 | 0.391107 | 0.000261727 | 0.0224314
3031350 | Level 4 | 0.32955 | 0.000261727 | 0.0189009
3031351 | Level 4 | 0.7555 | 0.000261727 | 0.0433307
3031352 | Level 4 | 3.4873 | 0.000261727 | 0.20001
3031353 | Level 4 | 0.2055 | 0.000261727 | 0.0117862
3031356 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031357 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031359 | Level 4 | 1.90457 | 0.000261727 | 0.109234
3031360 | Level 4 | 1.86706 | 0.000261727 | 0.107083
3031361 | Level 4 | 0.022438 | 0.000261727 | 0.0012869
3031362 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031363 | Level 4 | 0.171257 | 0.000261727 | 0.00982222
3031366 | Level 4 | 0.0119369 | 0.000261727 | 0.000684623
3031367 | Level 4 | 0.188638 | 0.000261727 | 0.0108191
3031368 | Level 4 | 0.6457 | 0.000261727 | 0.0370333
3031373 | Level 4 | 0.0635071 | 0.000261717 | 0.00364236
3031374 | Level 4 | 0.0893379 | 0.000261727 | 0.00512386
3031377 | Level 4 | 0.182857 | 0.000261727 | 0.0104875
3031383 | Level 4 | 0.158503 | 0.000261727 | 0.00909073
3031386 | Level 4 | 0.190632 | 0.000261727 | 0.0109334
3031387 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031388 | Level 4 | 0.05 | 0.000261727 | 0.00286769
3031391 | Level 4 | 0.00450539 | 0.000261727 | 0.000258401
3031394 | Level 4 | 0.112766 | 0.000261727 | 0.00646757
3031397 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031398 | Level 4 | 0.0234188 | 0.000261727 | 0.00134315
3031401 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031404 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031405 | Level 4 | 0.0234188 | 0.000261727 | 0.00134315
3031408 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031411 | Level 4 | 0.136901 | 0.000261727 | 0.00785178
3031418 | Level 4 | 1.74696 | 0.000261727 | 0.100195
3031425 | Level 4 | 0.297059 | 0.000261727 | 0.0170374
3031426 | Level 4 | 0.645459 | 0.000261727 | 0.0370195
3031427 | Level 4 | 1.04706 | 0.000261727 | 0.0600526
3031450 | Level 4 | 0.278619 | 0.000261727 | 0.0159798
3031451 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031452 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031453 | Level 4 | 0.0214432 | 0.000261727 | 0.00122985
3031454 | Level 4 | 1.15457 | 0.000261727 | 0.0662188
3031455 | Level 4 | 2.52133 | 0.000261727 | 0.144607
3031457 | Level 4 | 1.8555 | 0.000261727 | 0.10642
3031458 | Level 4 | 0.615816 | 0.000261727 | 0.0353193
3031460 | Level 4 | 0.85 | 0.000261727 | 0.0487506
3031461 | Level 4 | 0.335 | 0.000261727 | 0.0192135
3031462 | Level 4 | 0.195569 | 0.000261727 | 0.0112166
3031463 | Level 4 | 0.205569 | 0.000261727 | 0.0117901
3031465 | Level 4 | 0.639628 | 0.000261727 | 0.036685
3031466 | Level 4 | 1.51185 | 0.000261727 | 0.0867102
3031467 | Level 4 | 0.441527 | 0.000261717 | 0.0253232
3031469 | Level 4 | 1.048 | 0.000261727 | 0.0601068
3031470 | Level 4 | 0.102605 | 0.000261727 | 0.00588477
3031471 | Level 4 | 0.805 | 0.000261727 | 0.0461697
3031472 | Level 4 | 0.767058 | 0.000261727 | 0.0439936
3031473 | Level 4 | 0.296722 | 0.000261727 | 0.0170181
3031474 | Level 4 | 0.0169364 | 0.000261717 | 0.000971367
3031475 | Level 4 | 0.0408049 | 0.000261722 | 0.00234031
3031476 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031477 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031478 | Level 4 | 0.631374 | 0.000261727 | 0.0362116
3031479 | Level 4 | 0.1465 | 0.000261727 | 0.00840232
3031480 | Level 4 | 1.06711 | 0.000261727 | 0.0612025
3031481 | Level 4 | 0.0142587 | 0.000261727 | 0.000817789
3031485 | Level 4 | 0.824569 | 0.000261727 | 0.0472921
3031486 | Level 4 | 0.767057 | 0.000261727 | 0.0439936
3031489 | Level 4 | 2.1564 | 0.000261727 | 0.123678
3031490 | Level 4 | 0.216402 | 0.000261727 | 0.0124114
3031493 | Level 4 | 0.71239 | 0.000261717 | 0.0408582
3031494 | Level 4 | 0.941552 | 0.000261727 | 0.0540015
3031495 | Level 4 | 2.74157 | 0.000261717 | 0.157239
3031496 | Level 4 | 1.40806 | 0.000261727 | 0.0807573
3031497 | Level 4 | 0.589 | 0.000261727 | 0.0337813
3031498 | Level 4 | 0.43414 | 0.000261727 | 0.0248995
3031499 | Level 4 | 0.0103879 | 0.000261727 | 0.000595785
3031500 | Level 4 | 0.365602 | 0.000261727 | 0.0209686
3031501 | Level 4 | 0.0338912 | 0.000261727 | 0.00194379
3031502 | Level 4 | 1.11391 | 0.000261727 | 0.063887
3031505 | Level 4 | 0.310436 | 0.000261727 | 0.0178046
3031506 | Level 4 | 0.187113 | 0.000261727 | 0.0107316
3031507 | Level 4 | 0.0523645 | 0.000261727 | 0.0030033
3031510 | Level 4 | 1.8475 | 0.000261727 | 0.105961
3031514 | Level 4 | 0.4481 | 0.000261727 | 0.0257002
3031515 | Level 4 | 0.391107 | 0.000261727 | 0.0224314
3031516 | Level 4 | 0.241107 | 0.000261727 | 0.0138284
3031517 | Level 4 | 0.767057 | 0.000261727 | 0.0439936
3031518 | Level 4 | 3.49886 | 0.000261727 | 0.200672
3031519 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031522 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031524 | Level 4 | 1.90457 | 0.000261727 | 0.109234
3031525 | Level 4 | 1.8555 | 0.000261727 | 0.10642
3031526 | Level 4 | 1.22362 | 0.000261727 | 0.0701791
3031527 | Level 4 | 0.0124377 | 0.000261727 | 0.000713349
3031528 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031529 | Level 4 | 0.171257 | 0.000261727 | 0.00982222
3031534 | Level 4 | 0.0169369 | 0.000261727 | 0.000971391
3031535 | Level 4 | 0.258138 | 0.000261727 | 0.0148052
3031538 | Level 4 | 0.188638 | 0.000261727 | 0.0108191
3031541 | Level 4 | 0.657257 | 0.000261727 | 0.0376961
3031542 | Level 4 | 0.092445 | 0.000261717 | 0.00530206
3031545 | Level 4 | 0.0968611 | 0.000261727 | 0.00555534
3031546 | Level 4 | 0.182857 | 0.000261727 | 0.0104875
3031550 | Level 4 | 0.158503 | 0.000261727 | 0.00909073
3031553 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031554 | Level 4 | 0.085 | 0.000261727 | 0.00487506
3031557 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031560 | Level 4 | 0.0334442 | 0.000261727 | 0.00191815
3031567 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031568 | Level 4 | 0.0234188 | 0.000261727 | 0.00134315
3031571 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031574 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031575 | Level 4 | 0.0234188 | 0.000261727 | 0.00134315
3031578 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031581 | Level 4 | 0.14887 | 0.000261727 | 0.00853825
3031586 | Level 4 | 1.74696 | 0.000261727 | 0.100195
3031593 | Level 4 | 0.254567 | 0.000261727 | 0.0146003
3031594 | Level 4 | 1.548 | 0.000261727 | 0.0887836
3031595 | Level 4 | 0.645457 | 0.000261727 | 0.0370193
3031596 | Level 4 | 1.0355 | 0.000261727 | 0.0593897
3031597 | Level 4 | 0.2855 | 0.000261727 | 0.0163745
3031624 | Level 4 | 0.278619 | 0.000261727 | 0.0159798
3031625 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031626 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031627 | Level 4 | 0.027438 | 0.000261727 | 0.00157367
3031628 | Level 4 | 1.15457 | 0.000261717 | 0.0662188
3031629 | Level 4 | 0.804568 | 0.000261727 | 0.046145
3031630 | Level 4 | 0.804568 | 0.000261727 | 0.046145
3031631 | Level 4 | 2.56284 | 0.000261717 | 0.146988
3031633 | Level 4 | 1.8555 | 0.000261727 | 0.10642
3031634 | Level 4 | 0.615816 | 0.000261727 | 0.0353193
3031636 | Level 4 | 1.048 | 0.000261727 | 0.0601068
3031637 | Level 4 | 0.448 | 0.000261727 | 0.0256945
3031638 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031639 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031641 | Level 4 | 0.653897 | 0.000261727 | 0.0375034
3031642 | Level 4 | 1.51705 | 0.000261727 | 0.0870082
3031643 | Level 4 | 0.441527 | 0.000261717 | 0.0253232
3031645 | Level 4 | 0.998002 | 0.000261717 | 0.0572391
3031646 | Level 4 | 0.102603 | 0.000261727 | 0.00588469
3031647 | Level 4 | 0.0129369 | 0.000261717 | 0.000741977
3031648 | Level 4 | 0.0408183 | 0.000261727 | 0.00234108
3031649 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031650 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031651 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031652 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031653 | Level 4 | 0.0142642 | 0.000261727 | 0.000818107
3031657 | Level 4 | 0.824569 | 0.000261727 | 0.0472921
3031658 | Level 4 | 0.7555 | 0.000261727 | 0.0433307
3031661 | Level 4 | 2.1564 | 0.000261727 | 0.123678
3031662 | Level 4 | 0.216402 | 0.000261727 | 0.0124114
3031665 | Level 4 | 0.18442 | 0.000261727 | 0.0105772
3031666 | Level 4 | 0.941552 | 0.000261727 | 0.0540015
3031667 | Level 4 | 2.69157 | 0.000261727 | 0.154372
3031668 | Level 4 | 1.40806 | 0.000261727 | 0.0807573
3031669 | Level 4 | 0.589 | 0.000261727 | 0.0337813
3031670 | Level 4 | 0.429721 | 0.000261727 | 0.0246461
3031671 | Level 4 | 0.362602 | 0.000261727 | 0.0207966
3031672 | Level 4 | 0.0188879 | 0.000261727 | 0.00108329
3031675 | Level 4 | 1.10236 | 0.000261727 | 0.0632243
3031678 | Level 4 | 0.431477 | 0.000261727 | 0.0247468
3031679 | Level 4 | 0.243258 | 0.000261727 | 0.0139517
3031682 | Level 4 | 1.8475 | 0.000261727 | 0.105961
3031685 | Level 4 | 1.548 | 0.000261727 | 0.0887836
3031687 | Level 4 | 0.4481 | 0.000261727 | 0.0257002
3031688 | Level 4 | 0.391107 | 0.000261727 | 0.0224314
3031689 | Level 4 | 0.241107 | 0.000261727 | 0.0138284
3031690 | Level 4 | 0.7555 | 0.000261727 | 0.0433307
3031691 | Level 4 | 3.49886 | 0.000261727 | 0.200672
3031692 | Level 4 | 0.217057 | 0.000261727 | 0.012449
3031696 | Level 4 | 1.90457 | 0.000261727 | 0.109234
3031697 | Level 4 | 1.8555 | 0.000261727 | 0.10642
3031698 | Level 4 | 1.10942 | 0.000261717 | 0.0636293
3031699 | Level 4 | 0.017438 | 0.000261727 | 0.00100014
3031700 | Level 4 | 0.254569 | 0.000261727 | 0.0146005
3031701 | Level 4 | 0.208769 | 0.000261727 | 0.0119737
3031706 | Level 4 | 0.704326 | 0.000261727 | 0.0403957
3031707 | Level 4 | 0.193638 | 0.000261727 | 0.0111059
3031708 | Level 4 | 0.657257 | 0.000261717 | 0.0376961
3031709 | Level 4 | 0.102445 | 0.000261727 | 0.0058756
3031710 | Level 4 | 0.0893379 | 0.000261727 | 0.00512386
3031713 | Level 4 | 0.182857 | 0.000261727 | 0.0104875
3031715 | Level 4 | 0.158503 | 0.000261727 | 0.00909073
3031718 | Level 4 | 0.202181 | 0.000261727 | 0.0115958
3031719 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031720 | Level 4 | 0.075 | 0.000261727 | 0.00430153
3031723 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031726 | Level 4 | 0.571415 | 0.000261727 | 0.0327727
3031733 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031734 | Level 4 | 0.0234188 | 0.000261727 | 0.00134315
3031737 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
3031740 | Level 4 | 0.00450538 | 0.000261727 | 0.0002584
