Properties of the parts of a building model (IFC4), part 1 of 18

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 85934f00-ed4c-4d08-8d00-6888e0be2521, NumberOfSaves: 10], CoordinateReference [CoordinateBase: Shared Coordinates], ExchangeRequirement [BuildingService]
File name: Project Number
Time: 2024-11-18T11:29:22-05:00
Written by: ODA SDAI 22.12
Made in: 23.1.40.56 - Exporter 23.2.5.0 - Alternate UI 23.2.5.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: -35, -18, -23, -549194; RefLongitude: 149, 7, 35, 603027; RefElevation: 0 m
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 14
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:8mm Head (14)
Pset_BuildingStoreyCommon - Reference: 8mm Head
Name | LongName | Elevation (m)
Nivel 1 | Nivel 1 | 0
Level 2 | Level 2 | 0
Level 3 | Level 3 | 2.35
Nivel 2 | Nivel 2 | 2.35
Nivel 3 | Nivel 3 | 4.7
Level 4 | Level 4 | 4.7
Nivel 4 | Nivel 4 | 7.05
Level 5 | Level 5 | 7.05
Nivel 5 | Nivel 5 | 9.4
Level 6 | Level 6 | 9.4
Nivel 6 | Nivel 6 | 11.75
Level 7 | Level 7 | 11.75
Nivel 7 | Nivel 7 | 14.1
Level 8 | Level 8 | 14.1

# IfcBuildingElementProxy: Armarios Monofasicos:12 CTAS, Armarios Monofasicos:AM-1A 12 CTAS:1643084
In: Level 2
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5020.30 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 12 CTAS
Pset_EnvironmentalImpactIndicators - Reference: 12 CTAS
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.8168 m2; NetVolume: 0.4928 m3

# IfcBuildingElementProxy: Armarios Monofasicos:15 CTAS, Armarios Monofasicos:AM-1B 15 CTAS:1643155
In: Level 2
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5020.30 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 15 CTAS
Pset_EnvironmentalImpactIndicators - Reference: 15 CTAS
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.4376 m2; NetVolume: 0.59136 m3

# IfcBuildingElementProxy: Caja 3 Espacios:600x200x200 (6)
In: Level 2
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D6060 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 600x200x200
Pset_EnvironmentalImpactIndicators - Reference: 600x200x200
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.8064 m2; NetVolume: 0.02448 m3
Name (Caja 3 Espacios:600x200x200:...)
1668681
2246828
2246830
2246832
2246834
2246836

# IfcBuildingElementProxy: Caja Inspeccion Apantallamiento:Esc 50/75 (2)
In: Nivel 1
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5020.70 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Esc 50/75
Pset_EnvironmentalImpactIndicators - Reference: Esc 50/75
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.54 m2; NetVolume: 0.027 m3
Name (Caja Inspeccion Apantallamiento:Esc 50/75:...)
2767587
2768382

# IfcBuildingElementProxy: Caja para Amplificador de T.V:500x400x120, Caja para Amplificador de T.V:500x400x120:1678435
In: Level 2
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Pset_BuildingElementProxyCommon - Reference: 500x400x120
Pset_EnvironmentalImpactIndicators - Reference: 500x400x120
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.1672 m2; NetVolume: 0.0408 m3

# IfcBuildingElementProxy: Carcamo Lineal:Carcamo, Carcamo Lineal:Carcamo:1498283
In: Level 2
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5020.30 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Carcamo
Pset_EnvironmentalImpactIndicators - Reference: Carcamo
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.684 m2; NetVolume: 0.0867 m3

# IfcBuildingElementProxy: Interruptor Conmutable:Caja 2400 (24)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5040.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 2400
Pset_EnvironmentalImpactIndicators - Reference: Caja 2400
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0542377 m2; NetVolume: 0.000438577 m3
Name (Interruptor Conmutable:Caja 2400:...) | In
1489158 | Level 2
1533084 | Level 2
1541708 | Level 2
1554314 | Nivel 1 | Group: 3
1554942 | Nivel 1 | Group: 3
1555432 | Nivel 1 | Group: 3
1556158 | Nivel 1 | Group: 3
1588582 | Level 6
1588994 | Level 6
1589424 | Level 6
1589768 | Level 6
1985209 | Level 2
3025136 | Nivel 2
3025304 | Nivel 2
3025471 | Nivel 2
3025648 | Nivel 2
3031110 | Level 4
3031278 | Level 4
3031443 | Level 4
3031617 | Level 4
3033701 | Level 5
3033869 | Level 5
3034034 | Level 5
3034208 | Level 5

# IfcBuildingElementProxy: Interruptor Conmutable:Caja 5800 (24)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5040.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 5800
Pset_EnvironmentalImpactIndicators - Reference: Caja 5800
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0435184 m2; NetVolume: 0.000299205 m3
Name (Interruptor Conmutable:Caja 5800:...) | In
1489399 | Level 2
1527664 | Level 2
1533186 | Level 2
1541806 | Level 2
1554435 | Nivel 1 | Group: 3
1555040 | Nivel 1 | Group: 3
1555528 | Nivel 1 | Group: 3
1556263 | Nivel 1 | Group: 3
1588698 | Level 6
1589088 | Level 6
1589514 | Level 6
1589861 | Level 6
3025207 | Nivel 2
3025373 | Nivel 2
3025541 | Nivel 2
3025717 | Nivel 2
3031181 | Level 4
3031347 | Level 4
3031513 | Level 4
3031686 | Level 4
3033772 | Level 5
3033938 | Level 5
3034104 | Level 5
3034277 | Level 5

# IfcBuildingElementProxy: Interruptor Doble:Caja 2400 (24)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5040.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 2400
Pset_EnvironmentalImpactIndicators - Reference: Caja 2400
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0542377 m2; NetVolume: 0.000438577 m3
Name (Interruptor Doble:Caja 2400:...) | In
1489166 | Level 2
1527564 | Level 2
1533090 | Level 2
1541714 | Level 2
1554322 | Nivel 1 | Group: 3
1554948 | Nivel 1 | Group: 3
1555438 | Nivel 1 | Group: 3
1556164 | Nivel 1 | Group: 3
1588590 | Level 6
1589000 | Level 6
1589430 | Level 6
1589774 | Level 6
3025142 | Nivel 2
3025310 | Nivel 2
3025477 | Nivel 2
3025654 | Nivel 2
3031116 | Level 4
3031284 | Level 4
3031449 | Level 4
3031623 | Level 4
3033707 | Level 5
3033875 | Level 5
3034040 | Level 5
3034214 | Level 5

# IfcBuildingElementProxy: Interruptor Sencillo:Caja 2400 (95)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5040.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 2400
Pset_EnvironmentalImpactIndicators - Reference: Caja 2400
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0542377 m2; NetVolume: 0.000438577 m3
Name (Interruptor Sencillo:Caja 2400:...) | In
1489148 | Level 2
1489153 | Level 2
1489159 | Level 2
1518363 | Level 2 | Group: 3
1527549 | Level 2
1527553 | Level 2
1527558 | Level 2
1527559 | Level 2
1533075 | Level 2
1533079 | Level 2
1533085 | Level 2
1533305 | Level 2
1541699 | Level 2
1541703 | Level 2
1541709 | Level 2
1554304 | Nivel 1 | Group: 4
1554309 | Nivel 1 | Group: 4
1554315 | Nivel 1 | Group: 3
1554933 | Nivel 1
1554937 | Nivel 1 | Group: 4
1554943 | Nivel 1 | Group: 3
1555423 | Nivel 1 | Group: 4
1555427 | Nivel 1 | Group: 4
1555433 | Nivel 1 | Group: 3
1556149 | Nivel 1 | Group: 4
1556153 | Nivel 1 | Group: 4
1556159 | Nivel 1 | Group: 3
1588572 | Level 6
1588577 | Level 6
1588583 | Level 6
1588985 | Level 6
1588989 | Level 6
1588995 | Level 6
1589415 | Level 6
1589419 | Level 6
1589425 | Level 6
1589759 | Level 6
1589763 | Level 6
1589769 | Level 6
2771893 | Level 2
2802831 | Level 2
2825684 | Level 2
2849934 | Nivel 1
2860620 | Nivel 1
2867027 | Nivel 2
2871366 | Nivel 1
2878289 | Level 6
2883130 | Level 6
2888233 | Level 6
2892004 | Level 6
3025127 | Nivel 2
3025131 | Nivel 2
3025137 | Nivel 2
3025295 | Nivel 2
3025299 | Nivel 2
3025305 | Nivel 2
3025462 | Nivel 2
3025466 | Nivel 2
3025472 | Nivel 2
3025639 | Nivel 2
3025643 | Nivel 2
3025649 | Nivel 2
3026992 | Nivel 2
3027005 | Nivel 2
3027028 | Nivel 2
3031101 | Level 4
3031105 | Level 4
3031111 | Level 4
3031269 | Level 4
3031273 | Level 4
3031279 | Level 4
3031434 | Level 4
3031438 | Level 4
3031444 | Level 4
3031608 | Level 4
3031612 | Level 4
3031618 | Level 4
3032897 | Level 4
3032910 | Level 4
3032932 | Level 4
3033692 | Level 5
3033696 | Level 5
3033702 | Level 5
3033860 | Level 5
3033864 | Level 5
3033870 | Level 5
3034025 | Level 5
3034029 | Level 5
3034035 | Level 5
3034199 | Level 5
3034203 | Level 5
3034209 | Level 5
3035488 | Level 5
3035501 | Level 5
3035523 | Level 5

# IfcBuildingElementProxy: Interruptor Sencillo:Caja 5800 (2)
In: Level 2
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5040.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 5800
Pset_EnvironmentalImpactIndicators - Reference: Caja 5800
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0435184 m2; NetVolume: 0.000299205 m3
Name (Interruptor Sencillo:Caja 5800:...)
1527815
1541918

# IfcBuildingElementProxy: Sensor de Movimiento:Techo (6)
In: Nivel 6
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5040.10 Uniformat (Uniformat); Group: 1
Pset_BuildingElementProxyCommon - Reference: Techo
Pset_EnvironmentalImpactIndicators - Reference: Techo
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.189142 m2; NetVolume: 0.00208413 m3
Name (Sensor de Movimiento:Techo:...)
2746405
2746729
2746735
2746740
2746746
2746752

# IfcBuildingElementProxy: Sensor de Muro:Caja 2400 (5)
In: Nivel 6
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5040.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 2400
Pset_EnvironmentalImpactIndicators - Reference: Caja 2400
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0542377 m2; NetVolume: 0.000438577 m3
Name (Sensor de Muro:Caja 2400:...)
2746608
2747024
2747073
2747080
2747087

# IfcBuildingElementProxy: Tablero Monofásico:4 Circuitos, Tablero Monofásico:T-PF/13:1507278
In: Level 2
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5020.10 Uniformat (Uniformat); Group: 1; 2
Pset_BuildingElementProxyCommon - Reference: 4 Circuitos
Pset_EnvironmentalImpactIndicators - Reference: 4 Circuitos
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.280206 m2; NetVolume: 0.00360804 m3

# IfcBuildingElementProxy: Tablero Monofásico:6 Circuitos (24)
In: Level 2
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5020.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 6 Circuitos
Pset_EnvironmentalImpactIndicators - Reference: 6 Circuitos
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.326412 m2; NetVolume: 0.00428328 m3
Name (Tablero Monofásico:...)
T-103:1489143 | Group: 1; 2; 3; 4
T-203:1500246 | Group: 1; 2; 3; 4
T-303:1500277
T-403:1500286
T-503:1500295
T-603:1500304 | Group: 1; 2; 3; 4
T-102:1502569 | Group: 1; 2; 3; 4
T-202:1502805 | Group: 1; 2; 3; 4
T-302:1502814
T-402:1502823
T-502:1502832
T-602:1502841 | Group: 1; 2; 3; 4
T-104:1505064 | Group: 1; 2; 3; 4
T-101:1505160 | Group: 1; 2; 3; 4
T-204:1505297 | Group: 1; 2; 3; 4
T-201:1505299 | Group: 2; 3; 4; 1
T-304:1505306
T-301:1505307
T-404:1505316
T-401:1505317
T-504:1505326
T-501:1505327
T-604:1505336 | Group: 1; 2; 3; 4
T-601:1505337 | Group: 1; 2; 3; 4

# IfcBuildingElementProxy: Toma Citófono:Caja 5800 (15)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D6020 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 5800
Pset_EnvironmentalImpactIndicators - Reference: Caja 5800
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0456628 m2; NetVolume: 0.00030405 m3
Name (Toma Citófono:Caja 5800:...) | In
1963150 | Level 2
1963153 | Level 2
1963156 | Level 2
1963158 | Level 2
1963160 | Nivel 1
1963162 | Nivel 1
1963164 | Nivel 1
1987894 | Nivel 1
1987935 | Level 6
1987937 | Level 6
1987939 | Level 6
1987941 | Level 6
3025942 | Nivel 2
3031911 | Level 4
3034502 | Level 5

# IfcBuildingElementProxy: Toma Doble Normal (Chispero):Caja 2400 (24)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Pset_BuildingElementProxyCommon - Reference: Caja 2400
Pset_EnvironmentalImpactIndicators - Reference: Caja 2400
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0563821 m2; NetVolume: 0.000443421 m3
Name (Toma Doble Normal (Chispero):Caja 2400:...) | In
1489341 | Level 2 | Group: 2
1527642 | Level 2 | Group: 2
1533166 | Level 2 | Group: 2
1541788 | Level 2 | Group: 2
1554413 | Nivel 1 | Group: 2
1555022 | Nivel 1 | Group: 2
1555512 | Nivel 1 | Group: 2
1556242 | Nivel 1 | Group: 2
1588681 | Level 6 | Group: 2
1589074 | Level 6 | Group: 2
1589502 | Level 6 | Group: 2
1589848 | Level 6 | Group: 2
3025200 | Nivel 2
3025366 | Nivel 2
3025532 | Nivel 2
3025708 | Nivel 2
3031174 | Level 4
3031340 | Level 4
3031504 | Level 4
3031677 | Level 4
3033765 | Level 5
3033931 | Level 5
3034095 | Level 5
3034268 | Level 5

# IfcBuildingElementProxy: Toma Doble Normal (Esclava):Caja 5800 (23)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5030.50 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 5800
Pset_EnvironmentalImpactIndicators - Reference: Caja 5800
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0456628 m2; NetVolume: 0.00030405 m3
Name (Toma Doble Normal (Esclava):Caja 5800:...) | In
1489504 | Level 2 | Group: 2
1533208 | Level 2 | Group: 2
1541828 | Level 2 | Group: 2
1554459 | Nivel 1 | Group: 2
1555062 | Nivel 1 | Group: 2
1555550 | Nivel 1 | Group: 2
1556285 | Nivel 1 | Group: 2
1588722 | Level 6 | Group: 2
1589110 | Level 6 | Group: 2
1589534 | Level 6 | Group: 2
1589881 | Level 6 | Group: 2
3025217 | Nivel 2
3025384 | Nivel 2
3025551 | Nivel 2
3025726 | Nivel 2
3031191 | Level 4
3031358 | Level 4
3031523 | Level 4
3031695 | Level 4
3033782 | Level 5
3033949 | Level 5
3034114 | Level 5
3034286 | Level 5

# IfcBuildingElementProxy: Toma Doble Normal (Esclava-Calentador):Caja 2400 (24)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5030.50 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 2400
Pset_EnvironmentalImpactIndicators - Reference: Caja 2400
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0563821 m2; NetVolume: 0.000443421 m3
Name (Toma Doble Normal (Esclava-Calentador):Caja 2400:...) | In
1489144 | Level 2 | Group: 2
1527545 | Level 2 | Group: 2
1533071 | Level 2 | Group: 2
1541695 | Level 2 | Group: 2
1554300 | Nivel 1 | Group: 2
1554929 | Nivel 1 | Group: 2
1555419 | Nivel 1 | Group: 2
1556145 | Nivel 1 | Group: 2
1588568 | Level 6 | Group: 2
1588981 | Level 6 | Group: 2
1589411 | Level 6 | Group: 2
1589755 | Level 6 | Group: 2
3025123 | Nivel 2
3025291 | Nivel 2
3025458 | Nivel 2
3025635 | Nivel 2
3031097 | Level 4
3031265 | Level 4
3031430 | Level 4
3031604 | Level 4
3033688 | Level 5
3033856 | Level 5
3034021 | Level 5
3034195 | Level 5

# IfcBuildingElementProxy: Toma Doble Normal (Nevera):Caja 2400 (24)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5030.50 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 2400
Pset_EnvironmentalImpactIndicators - Reference: Caja 2400
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0563821 m2; NetVolume: 0.000443421 m3
Name (Toma Doble Normal (Nevera):Caja 2400:...) | In
1489142 | Level 2 | Group: 2
1527544 | Level 2 | Group: 2
1533070 | Level 2 | Group: 2
1541694 | Level 2 | Group: 2
1554299 | Nivel 1 | Group: 2
1554928 | Nivel 1 | Group: 2
1555418 | Nivel 1 | Group: 2
1556144 | Nivel 1 | Group: 2
1588567 | Level 6 | Group: 2
1588980 | Level 6 | Group: 2
1589410 | Level 6 | Group: 2
1589754 | Level 6 | Group: 2
3025122 | Nivel 2
3025290 | Nivel 2
3025457 | Nivel 2
3025634 | Nivel 2
3031096 | Level 4
3031264 | Level 4
3031429 | Level 4
3031603 | Level 4
3033687 | Level 5
3033855 | Level 5
3034020 | Level 5
3034194 | Level 5

# IfcBuildingElementProxy: Toma Doble Normal (Señal de Salida):Caja 2400 (6)
In: Nivel 6
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5030.50 Uniformat (Uniformat); Group: 2
Pset_BuildingElementProxyCommon - Reference: Caja 2400
Pset_EnvironmentalImpactIndicators - Reference: Caja 2400
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0563821 m2; NetVolume: 0.000443421 m3
Name (Toma Doble Normal (Señal de Salida):Caja 2400:...)
2744341
2744805
2745223
2745257
2745260
2745263

# IfcBuildingElementProxy: Toma Doble Normal:Caja 2400 (151)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5030.50 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 2400
Pset_EnvironmentalImpactIndicators - Reference: Caja 2400
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0563821 m2; NetVolume: 0.000443421 m3
Name (Toma Doble Normal:Caja 2400:...) | In | Group
1489146 | Level 2 | 4
1489147 | Level 2 | 4
1489152 | Level 2 | 4
1489157 | Level 2 | 3
1489163 | Level 2 | 4
1489469 | Level 2 | 3
1527547 | Level 2 | 4
1527548 | Level 2 | 4
1527552 | Level 2 | 4
1527557 | Level 2 | 3
1527561 | Level 2 | 4
1533073 | Level 2 | 4
1533074 | Level 2 | 4
1533078 | Level 2 | 4
1533083 | Level 2 | 3
1533087 | Level 2 | 4
1533204 | Level 2 | 3
1536567 | Level 2 | 3
1541697 | Level 2 | 4
1541698 | Level 2 | 4
1541702 | Level 2 | 4
1541707 | Level 2 | 3
1541711 | Level 2 | 4
1541824 | Level 2 | 3
1554302 | Nivel 1 | 4
1554303 | Nivel 1 | 4
1554308 | Nivel 1 | 4
1554313 | Nivel 1 | 3
1554319 | Nivel 1 | 4
1554453 | Nivel 1 | 3
1554931 | Nivel 1 | 4
1554932 | Nivel 1 | 4
1554936 | Nivel 1 | 4
1554941 | Nivel 1 | 3
1554945 | Nivel 1 | 4
1555058 | Nivel 1 | 3
1555421 | Nivel 1 | 4
1555422 | Nivel 1 | 4
1555426 | Nivel 1 | 4
1555431 | Nivel 1 | 3
1555435 | Nivel 1 | 4
1555546 | Nivel 1 | 3
1556147 | Nivel 1 | 4
1556148 | Nivel 1 | 4
1556152 | Nivel 1 | 4
1556157 | Nivel 1 | 3
1556161 | Nivel 1 | 4
1556281 | Nivel 1 | 3
1588570 | Level 6 | 4
1588571 | Level 6 | 4
1588576 | Level 6 | 4
1588580 | Level 6 | 3
1588581 | Level 6 | 3
1588587 | Level 6 | 4
1588716 | Level 6 | 3
1588983 | Level 6 | 4
1588984 | Level 6 | 4
1588988 | Level 6 | 4
1588992 | Level 6 | 3
1588993 | Level 6 | 3
1588997 | Level 6 | 4
1589106 | Level 6 | 3
1589413 | Level 6 | 4
1589414 | Level 6 | 4
1589418 | Level 6 | 4
1589422 | Level 6 | 3
1589423 | Level 6 | 3
1589427 | Level 6 | 4
1589530 | Level 6 | 3
1589757 | Level 6 | 4
1589758 | Level 6 | 4
1589762 | Level 6 | 4
1589766 | Level 6 | 3
1589767 | Level 6 | 3
1589771 | Level 6 | 4
1589877 | Level 6 | 3
2748257 | Nivel 2 | 1
2748433 | Nivel 2 | 1
2748445 | Nivel 2 | 1
3025125 | Nivel 2
3025126 | Nivel 2
3025130 | Nivel 2
3025135 | Nivel 2
3025139 | Nivel 2
3025215 | Nivel 2
3025293 | Nivel 2
3025294 | Nivel 2
3025298 | Nivel 2
3025303 | Nivel 2
3025307 | Nivel 2
3025381 | Nivel 2
3025460 | Nivel 2
3025461 | Nivel 2
3025465 | Nivel 2
3025470 | Nivel 2
3025474 | Nivel 2
3025549 | Nivel 2
3025637 | Nivel 2
3025638 | Nivel 2
3025642 | Nivel 2
3025647 | Nivel 2
3025651 | Nivel 2
3025725 | Nivel 2
3031099 | Level 4
3031100 | Level 4
3031104 | Level 4
3031109 | Level 4
3031113 | Level 4
3031189 | Level 4
3031267 | Level 4
3031268 | Level 4
3031272 | Level 4
3031277 | Level 4
3031281 | Level 4
3031355 | Level 4
3031432 | Level 4
3031433 | Level 4
3031437 | Level 4
3031442 | Level 4
3031446 | Level 4
3031521 | Level 4
3031606 | Level 4
3031607 | Level 4
3031611 | Level 4
3031616 | Level 4
3031620 | Level 4
3031694 | Level 4
3033690 | Level 5
3033691 | Level 5
3033695 | Level 5
3033700 | Level 5
3033704 | Level 5
3033780 | Level 5
3033858 | Level 5
3033859 | Level 5
3033863 | Level 5
3033868 | Level 5
3033872 | Level 5
3033946 | Level 5
3034023 | Level 5
3034024 | Level 5
3034028 | Level 5
3034033 | Level 5
3034037 | Level 5
3034112 | Level 5
3034197 | Level 5
3034198 | Level 5
3034202 | Level 5
3034207 | Level 5
3034211 | Level 5
3034285 | Level 5

# IfcBuildingElementProxy: Toma Doble Normal:Caja 5800 (68)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5030.50 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 5800
Pset_EnvironmentalImpactIndicators - Reference: Caja 5800
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0456628 m2; NetVolume: 0.00030405 m3
Name (Toma Doble Normal:Caja 5800:...) | In
1489145 | Level 2 | Group: 4
1489151 | Level 2 | Group: 4
1489156 | Level 2 | Group: 3
1527546 | Level 2 | Group: 4
1527551 | Level 2 | Group: 4
1527556 | Level 2 | Group: 3
1533072 | Level 2 | Group: 4
1533077 | Level 2 | Group: 4
1533082 | Level 2 | Group: 3
1541696 | Level 2 | Group: 4
1541701 | Level 2 | Group: 4
1541706 | Level 2 | Group: 3
1554301 | Nivel 1 | Group: 4
1554307 | Nivel 1 | Group: 4
1554312 | Nivel 1 | Group: 3
1554930 | Nivel 1 | Group: 4
1554935 | Nivel 1 | Group: 4
1554940 | Nivel 1 | Group: 3
1555420 | Nivel 1 | Group: 4
1555425 | Nivel 1 | Group: 4
1555430 | Nivel 1 | Group: 3
1556146 | Nivel 1 | Group: 4
1556151 | Nivel 1 | Group: 4
1556156 | Nivel 1 | Group: 3
1588569 | Level 6 | Group: 4
1588575 | Level 6 | Group: 4
1588982 | Level 6 | Group: 4
1588987 | Level 6 | Group: 4
1589412 | Level 6 | Group: 4
1589417 | Level 6 | Group: 4
1589756 | Level 6 | Group: 4
1589761 | Level 6 | Group: 4
3025124 | Nivel 2
3025129 | Nivel 2
3025134 | Nivel 2
3025292 | Nivel 2
3025297 | Nivel 2
3025302 | Nivel 2
3025459 | Nivel 2
3025464 | Nivel 2
3025469 | Nivel 2
3025636 | Nivel 2
3025641 | Nivel 2
3025646 | Nivel 2
3031098 | Level 4
3031103 | Level 4
3031108 | Level 4
3031266 | Level 4
3031271 | Level 4
3031276 | Level 4
3031431 | Level 4
3031436 | Level 4
3031441 | Level 4
3031605 | Level 4
3031610 | Level 4
3031615 | Level 4
3033689 | Level 5
3033694 | Level 5
3033699 | Level 5
3033857 | Level 5
3033862 | Level 5
3033867 | Level 5
3034022 | Level 5
3034027 | Level 5
3034032 | Level 5
3034196 | Level 5
3034201 | Level 5
3034206 | Level 5

# IfcBuildingElementProxy: Toma GFCI (Lavadora):Caja 5800 (24)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5030.50 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 5800
Pset_EnvironmentalImpactIndicators - Reference: Caja 5800
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0456628 m2; NetVolume: 0.00030405 m3
Name (Toma GFCI (Lavadora):Caja 5800:...) | In
1489141 | Level 2 | Group: 1
1527543 | Level 2 | Group: 1
1533069 | Level 2 | Group: 1
1541693 | Level 2 | Group: 1
1554298 | Nivel 1 | Group: 1
1554927 | Nivel 1 | Group: 1
1555417 | Nivel 1 | Group: 1
1556143 | Nivel 1 | Group: 1
1588566 | Level 6 | Group: 1
1588979 | Level 6 | Group: 1
1589409 | Level 6 | Group: 1
1589753 | Level 6 | Group: 1
3025121 | Nivel 2
3025289 | Nivel 2
3025456 | Nivel 2
3025633 | Nivel 2
3031095 | Level 4
3031263 | Level 4
3031428 | Level 4
3031602 | Level 4
3033686 | Level 5
3033854 | Level 5
3034019 | Level 5
3034193 | Level 5

# IfcBuildingElementProxy: Toma GFCI:Caja 2400 (48)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D5030.50 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 2400
Pset_EnvironmentalImpactIndicators - Reference: Caja 2400
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0563821 m2; NetVolume: 0.000443421 m3
Name (Toma GFCI:Caja 2400:...) | In
1489165 | Level 2 | Group: 3
1489340 | Level 2 | Group: 2
1527563 | Level 2 | Group: 3
1527641 | Level 2 | Group: 2
1533089 | Level 2 | Group: 3
1533165 | Level 2 | Group: 2
1541713 | Level 2 | Group: 3
1541787 | Level 2 | Group: 2
1554321 | Nivel 1 | Group: 3
1554412 | Nivel 1 | Group: 2
1554947 | Nivel 1 | Group: 3
1555021 | Nivel 1 | Group: 2
1555437 | Nivel 1 | Group: 3
1555511 | Nivel 1 | Group: 2
1556163 | Nivel 1 | Group: 3
1556241 | Nivel 1 | Group: 2
1588589 | Level 6 | Group: 3
1588680 | Level 6 | Group: 2
1588999 | Level 6 | Group: 3
1589073 | Level 6 | Group: 2
1589429 | Level 6 | Group: 3
1589501 | Level 6 | Group: 2
1589773 | Level 6 | Group: 3
1589847 | Level 6 | Group: 2
3025141 | Nivel 2
3025199 | Nivel 2
3025309 | Nivel 2
3025365 | Nivel 2
3025476 | Nivel 2
3025531 | Nivel 2
3025653 | Nivel 2
3025707 | Nivel 2
3031115 | Level 4
3031173 | Level 4
3031283 | Level 4
3031339 | Level 4
3031448 | Level 4
3031503 | Level 4
3031622 | Level 4
3031676 | Level 4
3033706 | Level 5
3033764 | Level 5
3033874 | Level 5
3033930 | Level 5
3034039 | Level 5
3034094 | Level 5
3034213 | Level 5
3034267 | Level 5

# IfcBuildingElementProxy: Toma Televisión:Caja 2400 (30)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D6030 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 2400
Pset_EnvironmentalImpactIndicators - Reference: Caja 2400
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0563821 m2; NetVolume: 0.000443421 m3
Name (Toma Televisión:Caja 2400:...) | In
1489149 | Level 2
1489161 | Level 2
1535872 | Level 2
1540280 | Level 2
1540281 | Level 2
1540605 | Level 2
1540606 | Level 2
1554305 | Nivel 1
1554317 | Nivel 1
1555248 | Nivel 1
1555249 | Nivel 1
1555322 | Nivel 1
1555323 | Nivel 1
1557185 | Nivel 1
1557186 | Nivel 1
1588573 | Level 6
1588585 | Level 6
1589252 | Level 6
1589253 | Level 6
1589323 | Level 6
1589324 | Level 6
1590042 | Level 6
1590043 | Level 6
1987703 | Level 2
3025791 | Nivel 2
3025792 | Nivel 2
3031760 | Level 4
3031761 | Level 4
3034351 | Level 5
3034352 | Level 5

# IfcBuildingElementProxy: Toma Teléfono:Caja 5800 (15)
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Classification: D6020 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Caja 5800
Pset_EnvironmentalImpactIndicators - Reference: Caja 5800
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0456628 m2; NetVolume: 0.00030405 m3
Name (Toma Teléfono:Caja 5800:...) | In
1489162 | Level 2
1535874 | Level 2
1540282 | Level 2
1540607 | Level 2
1554318 | Nivel 1
1555250 | Nivel 1
1555324 | Nivel 1
1557187 | Nivel 1
1588586 | Level 6
1589254 | Level 6
1589325 | Level 6
1590044 | Level 6
3025793 | Nivel 2
3031762 | Level 4
3034353 | Level 5

# IfcBuildingElementProxy: Varilla Puesta a Tierra:Con polo a tierra (2)
In: Nivel 1
Type - Material: <Unnamed>
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Pset_BuildingElementProxyCommon - Reference: Con polo a tierra
Pset_EnvironmentalImpactIndicators - Reference: Con polo a tierra
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.192243 m2; NetVolume: 0.00118014 m3
Name (Varilla Puesta a Tierra:Con polo a tierra:...)
2767588
2768383

# IfcCableCarrierFitting: Caja de Paso:2400 (241)
Type - Material: <Unnamed>
Classification: D5020.30 Uniformat (Uniformat)
Pset_CableCarrierFittingTypeCommon - Reference: 2400; sets with these values: 2
Name (Caja de Paso:2400:...) | In
1489183 | Level 2
1489198 | Level 2
1489207 | Level 2
1489217 | Level 2
1489264 | Level 2
1489270 | Level 2
1489396 | Level 2
1495057 | Level 2
1518523 | Level 2
1527573 | Level 2
1527576 | Level 2
1527587 | Level 2
1527611 | Level 2
1527615 | Level 2
1527662 | Level 2
1527772 | Level 2
1527817 | Level 2
1533099 | Level 2
1533102 | Level 2
1533107 | Level 2
1533113 | Level 2
1533136 | Level 2
1533140 | Level 2
1533184 | Level 2
1533281 | Level 2
1533306 | Level 2
1541723 | Level 2
1541726 | Level 2
1541731 | Level 2
1541737 | Level 2
1541759 | Level 2
1541763 | Level 2
1541805 | Level 2
1541901 | Level 2
1541919 | Level 2
1554331 | Nivel 1
1554334 | Nivel 1
1554339 | Nivel 1
1554345 | Nivel 1
1554369 | Nivel 1
1554373 | Nivel 1
1554433 | Nivel 1
1554545 | Nivel 1
1554957 | Nivel 1
1554960 | Nivel 1
1554965 | Nivel 1
1554971 | Nivel 1
1554993 | Nivel 1
1554997 | Nivel 1
1555039 | Nivel 1
1555135 | Nivel 1
1555447 | Nivel 1
1555450 | Nivel 1
1555455 | Nivel 1
1555461 | Nivel 1
1555483 | Nivel 1
1555487 | Nivel 1
1555527 | Nivel 1
1555623 | Nivel 1
1556173 | Nivel 1
1556176 | Nivel 1
1556181 | Nivel 1
1556187 | Nivel 1
1556211 | Nivel 1
1556215 | Nivel 1
1556261 | Nivel 1
1556359 | Nivel 1
1588599 | Level 6
1588602 | Level 6
1588607 | Level 6
1588613 | Level 6
1588637 | Level 6
1588641 | Level 6
1588696 | Level 6
1588796 | Level 6
1589009 | Level 6
1589012 | Level 6
1589017 | Level 6
1589023 | Level 6
1589087 | Level 6
1589439 | Level 6
1589442 | Level 6
1589447 | Level 6
1589453 | Level 6
1589513 | Level 6
1589783 | Level 6
1589786 | Level 6
1589791 | Level 6
1589797 | Level 6
1589859 | Level 6
1617258 | Level 6
1617260 | Level 6
1617283 | Level 6
1617306 | Level 6
1617308 | Level 6
1617329 | Level 6
1617338 | Level 6
1617347 | Level 6
1712471 | Level 6
1723161 | Nivel 1
1741096 | Level 6
1744490 | Level 6
1744495 | Level 6
1748039 | Level 6
1752425 | Level 6
1753546 | Level 6
1753548 | Level 6
1756104 | Nivel 1
1763140 | Nivel 1
1763145 | Nivel 1
1767915 | Nivel 1
1767920 | Nivel 2
1767934 | Nivel 1
1767939 | Nivel 1
1774125 | Level 2
1774130 | Level 2
1775863 | Level 2
1775868 | Level 2
1777790 | Level 2
1777795 | Level 2
1781197 | Level 2
1781202 | Level 2
1983568 | Level 2
2237881 | Level 6
3025151 | Nivel 2
3025154 | Nivel 2
3025159 | Nivel 2
3025163 | Nivel 2
3025180 | Nivel 2
3025184 | Nivel 2
3025205 | Nivel 2
3025244 | Nivel 2
3025319 | Nivel 2
3025322 | Nivel 2
3025327 | Nivel 2
3025331 | Nivel 2
3025345 | Nivel 2
3025349 | Nivel 2
3025372 | Nivel 2
3025408 | Nivel 2
3025484 | Nivel 2
3025487 | Nivel 2
3025492 | Nivel 2
3025496 | Nivel 2
3025512 | Nivel 2
3025516 | Nivel 2
3025540 | Nivel 2
3025577 | Nivel 2
3025663 | Nivel 2
3025666 | Nivel 2
3025671 | Nivel 2
3025675 | Nivel 2
3025687 | Nivel 2
3025691 | Nivel 2
3025715 | Nivel 2
3025745 | Nivel 2
3025860 | Nivel 2
3025863 | Nivel 2
3025877 | Nivel 2
3025880 | Nivel 2
3025895 | Nivel 2
3025911 | Nivel 2
3025914 | Nivel 2
3031125 | Level 4
3031128 | Level 4
3031133 | Level 4
3031137 | Level 4
3031154 | Level 4
3031158 | Level 4
3031179 | Level 4
3031218 | Level 4
3031293 | Level 4
3031296 | Level 4
3031301 | Level 4
3031305 | Level 4
3031319 | Level 4
3031323 | Level 4
3031346 | Level 4
3031382 | Level 4
3031456 | Level 4
3031459 | Level 4
3031464 | Level 4
3031468 | Level 4
3031484 | Level 4
3031488 | Level 4
3031512 | Level 4
3031549 | Level 4
3031632 | Level 4
3031635 | Level 4
3031640 | Level 4
3031644 | Level 4
3031656 | Level 4
3031660 | Level 4
3031684 | Level 4
3031714 | Level 4
3031829 | Level 4
3031832 | Level 4
3031846 | Level 4
3031849 | Level 4
3031864 | Level 4
3031880 | Level 4
3031883 | Level 4
3033716 | Level 5
3033719 | Level 5
3033724 | Level 5
3033728 | Level 5
3033745 | Level 5
3033749 | Level 5
3033770 | Level 5
3033809 | Level 5
3033884 | Level 5
3033887 | Level 5
3033892 | Level 5
3033896 | Level 5
3033910 | Level 5
3033914 | Level 5
3033937 | Level 5
3033973 | Level 5
3034047 | Level 5
3034050 | Level 5
3034055 | Level 5
3034059 | Level 5
3034075 | Level 5
3034079 | Level 5
3034103 | Level 5
3034140 | Level 5
3034223 | Level 5
3034226 | Level 5
3034231 | Level 5
3034235 | Level 5
3034247 | Level 5
3034251 | Level 5
3034275 | Level 5
3034305 | Level 5
3034420 | Level 5
3034423 | Level 5
3034437 | Level 5
3034440 | Level 5
3034455 | Level 5
3034471 | Level 5
3034474 | Level 5

# IfcCableCarrierFitting: Codo sin Restriccion:Standard (2698)
Type - Material: <Unnamed>
Classification: D5020 Uniformat (Uniformat)
Pset_CableCarrierFittingTypeCommon - Reference: Standard; sets with these values: 2
Name (Codo sin Restriccion:Standard:...) | In
1489275 | Level 2
1491184 | Level 2
1492242 | Level 2
1493766 | Level 2
1519235 | Level 2
1522080 | Level 2
1522083 | Level 2
1522228 | Level 2
1522255 | Level 2
1522257 | Level 2
1522299 | Level 2
1522302 | Level 2
1522418 | Level 2
1522441 | Level 2
1522468 | Level 2
1522471 | Level 2
1522545 | Level 2
1522567 | Level 2
1522570 | Level 2
1522613 | Level 2
1522650 | Level 2
1522696 | Level 2
1522699 | Level 2
1522731 | Level 2
1522734 | Level 2
1522823 | Level 2
1522825 | Level 2
1523059 | Level 2
1523084 | Level 2
1527740 | Level 2
1527745 | Level 2
1527847 | Level 2
1527850 | Level 2
1527854 | Level 2
1527857 | Level 2
1527860 | Level 2
1527862 | Level 2
1527871 | Level 2
1527875 | Level 2
1533000 | Level 2
1533143 | Level 2
1533239 | Level 2
1533251 | Level 2
1533256 | Level 2
1533309 | Level 2
1533320 | Level 2
1533323 | Level 2
1533328 | Level 2
1533332 | Level 2
1533336 | Level 2
1533339 | Level 2
1533343 | Level 2
1533346 | Level 2
1533349 | Level 2
1533351 | Level 2
1533360 | Level 2
1533364 | Level 2
1535905 | Level 2
1535908 | Level 2
1535913 | Level 2
1535915 | Level 2
1535917 | Level 2
1538073 | Level 2
1538366 | Level 2
1538369 | Level 2
1538494 | Level 2
1538650 | Level 2
1538673 | Level 2
1538675 | Level 2
1538715 | Level 2
1538718 | Level 2
1538856 | Level 2
1538927 | Level 2
1540313 | Level 2
1540316 | Level 2
1540321 | Level 2
1540323 | Level 2
1540325 | Level 2
1540331 | Level 2
1540334 | Level 2
1540337 | Level 2
1540341 | Level 2
1540344 | Level 2
1540349 | Level 2
1540353 | Level 2
1540629 | Level 2
1540632 | Level 2
1540637 | Level 2
1540639 | Level 2
1540641 | Level 2
1540647 | Level 2
1540650 | Level 2
1540653 | Level 2
1540657 | Level 2
1540660 | Level 2
1540665 | Level 2
1540669 | Level 2
1541766 | Level 2
1541871 | Level 2
1541922 | Level 2
1541933 | Level 2
1541936 | Level 2
1541941 | Level 2
1541945 | Level 2
1541949 | Level 2
1541952 | Level 2
1541956 | Level 2
1541959 | Level 2
1541962 | Level 2
1541964 | Level 2
1541971 | Level 2
1541975 | Level 2
1554376 | Nivel 1
1554478 | Nivel 1
1554612 | Nivel 1
1554615 | Nivel 1
1554620 | Nivel 1
1554622 | Nivel 1
1554624 | Nivel 1
1554628 | Nivel 1
1554631 | Nivel 1
1554636 | Nivel 1
1554640 | Nivel 1
1554654 | Nivel 1
1554657 | Nivel 1
1554662 | Nivel 1
1554666 | Nivel 1
1554670 | Nivel 1
1554673 | Nivel 1
1554677 | Nivel 1
1554680 | Nivel 1
1554683 | Nivel 1
1554685 | Nivel 1
1554694 | Nivel 1
1554698 | Nivel 1
1555000 | Nivel 1
1555016 | Nivel 1
1555110 | Nivel 1
1555167 | Nivel 1
1555170 | Nivel 1
1555179 | Nivel 1
1555183 | Nivel 1
1555186 | Nivel 1
1555190 | Nivel 1
1555193 | Nivel 1
1555196 | Nivel 1
1555198 | Nivel 1
1555200 | Nivel 1
1555205 | Nivel 1
1555209 | Nivel 1
1555272 | Nivel 1
1555275 | Nivel 1
1555280 | Nivel 1
1555282 | Nivel 1
1555284 | Nivel 1
1555288 | Nivel 1
1555291 | Nivel 1
1555294 | Nivel 1
1555298 | Nivel 1
1555301 | Nivel 1
1555306 | Nivel 1
1555310 | Nivel 1
1555344 | Nivel 1
1555347 | Nivel 1
1555352 | Nivel 1
1555354 | Nivel 1
1555356 | Nivel 1
1555360 | Nivel 1
1555363 | Nivel 1
1555366 | Nivel 1
1555370 | Nivel 1
1555373 | Nivel 1
1555378 | Nivel 1
1555382 | Nivel 1
1555490 | Nivel 1
1555567 | Nivel 1
1555574 | Nivel 1
1555593 | Nivel 1
1555653 | Nivel 1
1555656 | Nivel 1
1555661 | Nivel 1
1555665 | Nivel 1
1555669 | Nivel 1
1555672 | Nivel 1
1555676 | Nivel 1
1555679 | Nivel 1
1555682 | Nivel 1
1555684 | Nivel 1
1555691 | Nivel 1
1555695 | Nivel 1
1556218 | Nivel 1
1556236 | Nivel 1
1556338 | Nivel 1
1556395 | Nivel 1
1556398 | Nivel 1
1556403 | Nivel 1
1556407 | Nivel 1
1556411 | Nivel 1
1556414 | Nivel 1
1556418 | Nivel 1
1556421 | Nivel 1
1556426 | Nivel 1
1556430 | Nivel 1
1556435 | Nivel 1
1557213 | Nivel 1
1557216 | Nivel 1
1557221 | Nivel 1
1557223 | Nivel 1
1557225 | Nivel 1
1557229 | Nivel 1
1557232 | Nivel 1
1557235 | Nivel 1
1557239 | Nivel 1
1557242 | Nivel 1
1557247 | Nivel 1
1557251 | Nivel 1
1588840 | Level 6
1588843 | Level 6
1588848 | Level 6
1588850 | Level 6
1588852 | Level 6
1588856 | Level 6
1588859 | Level 6
1588864 | Level 6
1588868 | Level 6
1588872 | Level 6
1588875 | Level 6
1588878 | Level 6
1588882 | Level 6
1588885 | Level 6
1588890 | Level 6
1588894 | Level 6
1588898 | Level 6
1588901 | Level 6
1589201 | Level 6
1589204 | Level 6
1589209 | Level 6
1589213 | Level 6
1589217 | Level 6
1589220 | Level 6
1589239 | Level 6
1589243 | Level 6
1589276 | Level 6
1589279 | Level 6
1589284 | Level 6
1589286 | Level 6
1589288 | Level 6
1589292 | Level 6
1589295 | Level 6
1589298 | Level 6
1589302 | Level 6
1589305 | Level 6
1589310 | Level 6
1589314 | Level 6
1589345 | Level 6
1589348 | Level 6
1589353 | Level 6
1589355 | Level 6
1589357 | Level 6
1589361 | Level 6
1589364 | Level 6
1589367 | Level 6
1589371 | Level 6
1589374 | Level 6
1589379 | Level 6
1589383 | Level 6
1589601 | Level 6
1589604 | Level 6
1589609 | Level 6
1589613 | Level 6
1589617 | Level 6
1589620 | Level 6
1589639 | Level 6
1589643 | Level 6
1589965 | Level 6
1589968 | Level 6
1589993 | Level 6
1590066 | Level 6
1590069 | Level 6
1590074 | Level 6
1590076 | Level 6
1590078 | Level 6
1590082 | Level 6
1590085 | Level 6
1590088 | Level 6
1590092 | Level 6
1590095 | Level 6
1590100 | Level 6
1590104 | Level 6
1617318 | Level 6
1651735 | Level 2
1651785 | Level 2
1652329 | Level 2
1652497 | Level 2
1652646 | Level 2
1652733 | Level 2
1652763 | Level 2
1652902 | Level 2
1652912 | Level 2
1652968 | Level 2
1653036 | Level 2
1653236 | Level 2
1654433 | Level 2
1655230 | Level 2
1655448 | Level 2
1655544 | Level 2
1655619 | Level 2
1655671 | Level 2
1655752 | Level 2
1655852 | Level 2
1655893 | Level 2
1656063 | Level 2
1656198 | Level 2
1665296 | Level 2
1666742 | Level 2
1666745 | Level 2
1666747 | Level 2
1666749 | Level 2
1666861 | Level 2
1666865 | Level 2
1666869 | Level 2
1666873 | Level 2
1666886 | Level 2
1666890 | Level 2
1666892 | Level 2
1666894 | Level 2
1666898 | Level 2
1666900 | Level 2
1667155 | Level 2
1667531 | Level 2
1667636 | Level 2
1667918 | Level 2
1667920 | Level 2
1667924 | Level 2
1667926 | Level 2
1667928 | Level 2
1667932 | Level 2
1667936 | Level 2
1667940 | Level 2
1667944 | Level 2
1667949 | Level 2
1667951 | Level 2
1668270 | Level 2
1673581 | Level 2
1674282 | Level 2
1682456 | Level 6
1683541 | Level 2
1683565 | Level 2
1683582 | Level 2
1683584 | Level 2
1683616 | Level 2
1685280 | Level 2
1686817 | Level 2
1686820 | Level 2
1687514 | Level 2
1687711 | Level 2
1687777 | Level 2
1687779 | Level 2
1687802 | Level 2
1687804 | Level 2
1760861 | Nivel 1
1760869 | Nivel 1
1760880 | Nivel 1
1761046 | Nivel 1
1763148 | Nivel 1
1763151 | Nivel 1
1763154 | Nivel 1
1763156 | Nivel 1
1767923 | Nivel 1
1767926 | Nivel 1
1767929 | Nivel 1
1767931 | Nivel 1
1767942 | Nivel 1
1767945 | Nivel 1
1767948 | Nivel 1
1767950 | Nivel 1
1774133 | Level 2
1774136 | Level 2
1774139 | Level 2
1774141 | Level 2
1775871 | Level 2
1775874 | Level 2
1775877 | Level 2
1775879 | Level 2
1777798 | Level 2
1777801 | Level 2
1777804 | Level 2
1777806 | Level 2
1781205 | Level 2
1781208 | Level 2
1781211 | Level 2
1781213 | Level 2
1802157 | Level 2
1803612 | Level 2
1807585 | Level 2
1810730 | Level 2
1810737 | Level 2
1830251 | Level 2
1837014 | Nivel 1
1839136 | Nivel 1
1841267 | Nivel 1
1842920 | Nivel 1
1850581 | Level 6
1853019 | Level 6
1854583 | Level 6
1983576 | Level 2
1985350 | Level 2
1985504 | Level 2
1985516 | Level 2
1985668 | Level 2
1985670 | Level 2
1987728 | Level 2
1987784 | Level 2
1987786 | Level 2
2006056 | Nivel 1
2006058 | Nivel 1
2006060 | Nivel 1
2006062 | Nivel 1
2006067 | Nivel 1
2006069 | Nivel 1
2006071 | Nivel 1
2006075 | Nivel 1
2006081 | Nivel 1
2006083 | Nivel 1
2006085 | Nivel 1
2006089 | Nivel 1
2006098 | Nivel 1
2006100 | Nivel 1
2006105 | Nivel 1
2006107 | Nivel 2
2006118 | Nivel 1
2006120 | Nivel 1
2006144 | Nivel 1
2006148 | Nivel 1
2006155 | Nivel 1
2006159 | Nivel 1
2006175 | Nivel 1
2006895 | Nivel 1
2006983 | Nivel 1
2007072 | Nivel 1
2007075 | Nivel 1
2007189 | Nivel 1
2007192 | Nivel 1
2007211 | Nivel 1
2007213 | Nivel 1
2008683 | Nivel 1
2012009 | Nivel 1
2012036 | Nivel 1
2012300 | Nivel 1
2016167 | Level 2
2016219 | Level 2
2016221 | Level 2
2016548 | Level 2
2016577 | Level 2
2016579 | Level 2
2016670 | Level 2
2016684 | Level 2
2016705 | Level 2
2016707 | Level 2
2017206 | Level 2
2018083 | Level 2
2018085 | Level 2
2018207 | Level 2
2018209 | Level 2
2018366 | Level 2
2018601 | Level 2
2018635 | Level 2
2018637 | Level 2
2018705 | Level 2
2018803 | Level 2
2018805 | Level 2
2019883 | Level 2
2019912 | Level 2
2019915 | Level 2
2020400 | Level 2
2020409 | Level 2
2020411 | Level 2
2021032 | Level 2
2021054 | Level 2
2021474 | Level 2
2021626 | Level 2
2021628 | Level 2
2021873 | Level 2
2021989 | Level 2
2021991 | Level 2
2022453 | Level 2
2022462 | Level 2
2022471 | Level 2
2022476 | Level 2
2022896 | Level 2
2022905 | Level 2
2022914 | Level 2
2022916 | Level 2
2023214 | Level 2
2023223 | Level 2
2023237 | Level 2
2023356 | Level 2
2023359 | Level 2
2026565 | Level 2
2026794 | Level 2
2026796 | Level 2
2027031 | Level 2
2027556 | Level 2
2040963 | Level 2
2065254 | Level 2
2065265 | Level 2
2065289 | Level 2
2065291 | Level 2
2068012 | Level 2
2068021 | Level 2
2068041 | Level 2
2068043 | Level 2
2068143 | Level 2
2069830 | Level 2
2069842 | Level 2
2069851 | Level 2
2071083 | Level 2
2071193 | Level 2
2071196 | Level 2
2074507 | Nivel 1
2074514 | Nivel 1
2074516 | Nivel 1
2074520 | Nivel 1
2074522 | Nivel 1
2074531 | Nivel 1
2074533 | Nivel 1
2074540 | Nivel 1
2074551 | Nivel 1
2074553 | Nivel 2
2074555 | Nivel 2
2074557 | Nivel 1
2074560 | Nivel 1
2074566 | Nivel 1
2074591 | Nivel 1
2074600 | Nivel 1
2074608 | Nivel 1
2074611 | Nivel 1
2074643 | Nivel 2
2074645 | Nivel 1
2074656 | Nivel 1
2074790 | Nivel 1
2075247 | Level 2
2076905 | Level 2
2076940 | Level 2
2076942 | Level 2
2082910 | Nivel 1
2082912 | Nivel 1
2082939 | Nivel 1
2082944 | Nivel 1
2085036 | Nivel 1
2085039 | Nivel 1
2085044 | Nivel 1
2085046 | Nivel 1
2085048 | Nivel 1
2085329 | Nivel 1
2085604 | Nivel 1
2085666 | Nivel 1
2087888 | Nivel 1
2087890 | Nivel 1
2089247 | Nivel 1
2094973 | Nivel 1
2103369 | Level 2
2103375 | Level 2
2103383 | Level 2
2103385 | Level 2
2103388 | Level 2
2103390 | Level 2
2103398 | Level 2
2103403 | Level 2
2103411 | Level 2
2103413 | Level 2
2103415 | Level 2
2103417 | Level 2
2103419 | Level 2
2103421 | Level 2
2103427 | Level 2
2103430 | Level 2
2103432 | Level 2
2105105 | Level 2
2105128 | Level 2
2105130 | Level 2
2105340 | Level 2
2107904 | Level 2
2118095 | Level 2
2124257 | Nivel 1
2124263 | Nivel 1
2124265 | Nivel 1
2124267 | Nivel 1
2124279 | Nivel 1
2124281 | Nivel 1
2124286 | Nivel 1
2124298 | Nivel 1
2124300 | Nivel 1
2124309 | Nivel 1
2124331 | Nivel 1
2125596 | Nivel 1
2126857 | Nivel 1
2126859 | Nivel 1
2130475 | Nivel 1
2130537 | Nivel 1
2130539 | Nivel 1
2130541 | Nivel 1
2132887 | Nivel 1
2132932 | Nivel 1
2132972 | Nivel 1
2136265 | Nivel 1
2136268 | Nivel 1
2136271 | Nivel 1
2136273 | Nivel 1
2136275 | Nivel 1
2136277 | Nivel 1
2136403 | Nivel 1
2137935 | Nivel 1
2141862 | Nivel 1
2141922 | Nivel 1
2142459 | Nivel 1
2142461 | Nivel 1
2156547 | Level 2
2156585 | Level 2
2156599 | Level 2
2156601 | Level 2
2156833 | Level 2
2156868 | Level 2
2156887 | Level 2
2158325 | Level 2
2158347 | Level 2
2158354 | Level 2
2158356 | Level 2
2158989 | Level 2
2159039 | Level 2
2159041 | Level 2
2159043 | Level 2
2160728 | Level 2
2160737 | Level 2
2160753 | Level 2
2160760 | Level 2
2161357 | Nivel 1
2162054 | Level 2
2162071 | Level 2
2162073 | Level 2
2163702 | Level 2
2163720 | Level 2
2163906 | Level 2
2164172 | Level 2
2164235 | Level 2
2164237 | Level 2
2164276 | Level 2
2164278 | Level 2
2171287 | Level 2
2171366 | Level 2
2186001 | Level 2
2197716 | Level 2
2197761 | Level 2
2197826 | Level 2
2197829 | Level 2
2197873 | Level 2
2197875 | Level 2
2197904 | Level 2
2197906 | Level 2
2200129 | Level 2
2200131 | Level 2
2210040 | Nivel 1
2210044 | Nivel 1
2210046 | Nivel 1
2210050 | Nivel 1
2210064 | Nivel 1
2210068 | Nivel 1
2210070 | Nivel 1
2210072 | Nivel 1
2210076 | Nivel 1
2210078 | Nivel 1
2210092 | Nivel 1
2210094 | Nivel 1
2210110 | Nivel 1
2210117 | Nivel 1
2210121 | Nivel 1
2210125 | Nivel 1
2210131 | Nivel 1
2210133 | Nivel 1
2210148 | Nivel 1
2210154 | Nivel 1
2210157 | Nivel 1
2210159 | Nivel 1
2210163 | Nivel 1
2210177 | Nivel 1
2210180 | Nivel 1
2210183 | Nivel 1
2210185 | Nivel 1
2210187 | Nivel 1
2210189 | Nivel 1
2210218 | Nivel 1
2210221 | Nivel 1
2210231 | Nivel 1
2210240 | Nivel 1
2210246 | Nivel 1
2210248 | Nivel 1
2210280 | Nivel 1
2236876 | Level 2
2237490 | Level 6
2237492 | Level 6
2237506 | Level 6
2237512 | Level 6
2237522 | Level 6
2237524 | Level 6
2237528 | Level 6
2237530 | Level 6
2237549 | Level 6
2237551 | Level 6
2237553 | Level 6
2237560 | Level 6
2237562 | Level 6
2237569 | Level 6
2237599 | Level 6
2237601 | Level 6
2237641 | Level 6
2237644 | Level 6
2237647 | Level 6
2237649 | Level 6
2237651 | Level 6
2237656 | Level 6
2237667 | Level 6
2237669 | Level 6
2237676 | Level 6
2237678 | Level 6
2237685 | Level 6
2237687 | Level 6
2237697 | Level 6
2237703 | Level 6
2237706 | Level 6
2237709 | Level 6
2237711 | Level 6
2237713 | Level 6
2237715 | Level 6
2237731 | Level 6
2237831 | Level 6
2237846 | Level 6
2237848 | Level 6
2237850 | Level 6
2237868 | Level 6
2237874 | Level 6
2237886 | Level 6
2237897 | Level 6
2237899 | Level 6
2237935 | Level 6
2237940 | Level 6
2237950 | Level 6
2237952 | Level 6
2237961 | Level 6
2237970 | Level 6
2237986 | Level 6
2237988 | Level 6
2237992 | Level 6
2238011 | Level 6
2238083 | Level 6
2238191 | Level 6
2238297 | Level 6
2239762 | Level 6
2239764 | Level 6
2240149 | Level 6
2240783 | Level 6
2240888 | Level 6
2243635 | Level 6
2243639 | Level 6
2243642 | Level 6
2243645 | Level 6
2243647 | Level 6
2243652 | Level 6
2243658 | Level 6
2243662 | Level 6
2243664 | Level 6
2243852 | Level 6
2243915 | Level 6
2244283 | Level 6
2245249 | Level 6
2246779 | Level 2
2248114 | Level 2
2248121 | Level 2
2248177 | Level 2
2252724 | Level 2
2258417 | Level 2
2258538 | Level 2
2258592 | Level 2
2258616 | Level 2
2258618 | Level 2
2259371 | Level 2
2259416 | Level 2
2260991 | Level 2
2260993 | Level 2
2261269 | Level 2
2261271 | Level 2
2261301 | Level 2
2261328 | Level 2
2261349 | Level 2
2261367 | Level 2
2261410 | Level 2
2261412 | Level 2
2261417 | Level 2
2261419 | Level 2
2261705 | Level 2
2261724 | Level 2
2261732 | Level 2
2261736 | Level 2
2261744 | Level 2
2262276 | Level 2
2262278 | Level 2
2262861 | Level 2
2265264 | Level 2
2265377 | Level 2
2265493 | Level 2
2265616 | Level 2
2265908 | Level 2
2265910 | Level 2
2265912 | Level 2
2265914 | Level 2
2265917 | Level 2
2266055 | Level 2
2266058 | Level 2
2266210 | Level 2
2266273 | Level 2
2266275 | Level 2
2266450 | Level 2
2266452 | Level 2
2272214 | Level 2
2272217 | Level 2
2272335 | Level 2
2272338 | Level 2
2272504 | Level 2
2272535 | Level 2
2272644 | Level 2
2272669 | Level 2
2272671 | Level 2
2272737 | Level 2
2272739 | Level 2
2272914 | Level 2
2272916 | Level 2
2273535 | Level 6
2273538 | Level 6
2273541 | Level 6
2273543 | Level 6
2273545 | Level 6
2273547 | Level 6
2273563 | Level 6
2273565 | Level 6
2273572 | Level 6
2273575 | Level 6
2273582 | Level 6
2273588 | Level 6
2273601 | Level 6
2273603 | Level 6
2273605 | Level 6
2273641 | Level 6
2273648 | Level 6
2273652 | Level 6
2273722 | Level 6
2273750 | Level 6
2278509 | Level 2
2285019 | Level 6
2285455 | Level 6
2285457 | Level 6
2285673 | Level 6
2285867 | Level 6
2285914 | Level 2
2285922 | Level 2
2285924 | Level 2
2285930 | Level 2
2285932 | Level 2
2285934 | Level 2
2285936 | Level 2
2285938 | Level 2
2285975 | Level 2
2285977 | Level 2
2285980 | Level 2
2285988 | Level 2
2285990 | Level 2
2286005 | Level 2
2286007 | Level 2
2286010 | Level 2
2286024 | Level 2
2286026 | Level 2
2286028 | Level 2
2286030 | Level 2
2286032 | Level 2
2286035 | Level 2
2287258 | Nivel 1
2287344 | Level 6
2287346 | Level 6
2287349 | Level 6
2287365 | Level 6
2287367 | Level 6
2287370 | Level 6
2287373 | Level 6
2288322 | Level 6
2288328 | Level 6
2288330 | Level 6
2288751 | Level 6
2291378 | Level 6
2293005 | Level 6
2293008 | Level 6
2293011 | Level 6
2293013 | Level 6
2293019 | Level 6
2293021 | Level 6
2293059 | Level 6
2293063 | Level 6
2293065 | Level 6
2293358 | Level 6
2293414 | Level 6
2293872 | Level 6
2297801 | Level 6
2297804 | Level 6
2297807 | Level 6
2297809 | Level 6
2297811 | Level 6
2297813 | Level 6
2297815 | Level 6
2297876 | Level 6
2306335 | Level 6
2306337 | Level 6
2306339 | Level 6
2310824 | Level 2
2311588 | Level 6
2312456 | Level 6
2315777 | Level 6
2317165 | Level 6
2317167 | Level 6
2317971 | Level 6
2317973 | Level 6
2318843 | Level 6
2319142 | Level 6
2319562 | Level 6
2319570 | Level 6
2319572 | Level 6
2319577 | Level 6
2319584 | Level 6
2319586 | Level 6
2319589 | Level 6
2320320 | Level 6
2320379 | Level 6
2320488 | Level 6
2321649 | Level 6
2321791 | Level 6
2323417 | Level 6
2324688 | Level 6
2325271 | Level 6
2325274 | Level 6
2325277 | Level 6
2325279 | Level 6
2325282 | Level 6
2325284 | Level 6
2325295 | Level 6
2325297 | Level 6
2325364 | Level 6
2325422 | Level 6
2325584 | Level 6
2325822 | Level 6
2329001 | Level 6
2329004 | Level 6
2329007 | Level 6
2329009 | Level 6
2329011 | Level 6
2329013 | Level 6
2329712 | Level 6
2329805 | Level 6
2332809 | Level 6
2333559 | Level 6
2333561 | Level 6
2333563 | Level 6
2334781 | Level 6
2334839 | Level 6
2335599 | Level 6
2335829 | Level 6
2335833 | Level 6
2365618 | Nivel 1
2365636 | Nivel 1
2365638 | Nivel 1
2365703 | Nivel 1
2365705 | Nivel 1
2365732 | Nivel 1
2365734 | Nivel 1
2365774 | Nivel 1
2365776 | Nivel 1
2365811 | Nivel 1
2366176 | Nivel 1
2366209 | Nivel 1
2366415 | Nivel 1
2367598 | Nivel 1
2367601 | Nivel 1
2367703 | Nivel 1
2367724 | Nivel 1
2367726 | Nivel 1
2371169 | Nivel 1
2371568 | Nivel 1
2371570 | Nivel 1
2371656 | Nivel 1
2371659 | Nivel 1
2371813 | Nivel 1
2371948 | Nivel 1
2371951 | Nivel 1
2373170 | Nivel 1
2373184 | Nivel 1
2373333 | Nivel 1
2373336 | Nivel 1
2373417 | Nivel 1
2373419 | Nivel 1
2373483 | Nivel 1
2373610 | Nivel 1
2373625 | Nivel 1
2373768 | Nivel 1
2373770 | Nivel 1
2373811 | Nivel 1
2373814 | Nivel 1
2374022 | Nivel 1
2374024 | Nivel 1
2375749 | Nivel 1
2375832 | Nivel 1
2376118 | Nivel 1
2376125 | Nivel 1
2376129 | Nivel 1
2376540 | Nivel 1
2376635 | Nivel 1
2376637 | Nivel 1
2376701 | Nivel 1
2377910 | Nivel 1
2377912 | Nivel 1
2377931 | Nivel 1
2377933 | Nivel 1
2378090 | Nivel 1
2378092 | Nivel 1
2378217 | Nivel 1
2378274 | Nivel 1
2378276 | Nivel 1
2378305 | Nivel 1
2378307 | Nivel 1
2378709 | Nivel 1
2378711 | Nivel 1
2378730 | Nivel 1
2378732 | Nivel 1
2378758 | Nivel 1
2380714 | Nivel 1
2380720 | Nivel 1
2381568 | Level 6
2381577 | Level 6
2381579 | Level 6
2381581 | Level 6
2381583 | Level 6
2381585 | Level 6
2381587 | Level 6
2381589 | Level 6
2381595 | Level 6
2381597 | Level 6
2381609 | Level 6
2381611 | Level 6
2381613 | Level 6
2381615 | Level 6
2381620 | Level 6
2381623 | Level 6
2381625 | Level 6
2381631 | Level 6
2381634 | Level 6
2381639 | Level 6
2381642 | Level 6
2381645 | Level 6
2381647 | Level 6
2381649 | Level 6
2381654 | Level 6
2381657 | Level 6
2381659 | Level 6
2381661 | Level 6
2381665 | Level 6
2381668 | Level 6
2381671 | Level 6
2381673 | Level 6
2381681 | Level 6
2381691 | Level 6
2381707 | Level 6
2381709 | Level 6
2381711 | Level 6
2381713 | Level 6
2381718 | Level 6
2381720 | Level 6
2381726 | Level 6
2381728 | Level 6
2381732 | Level 6
2381734 | Level 6
2381736 | Level 6
2381738 | Level 6
2381744 | Level 6
2381750 | Level 6
2383131 | Level 6
2383150 | Level 6
2383152 | Level 6
2383176 | Level 6
2383601 | Level 6
2383658 | Level 6
2385430 | Level 6
2385457 | Level 6
2385459 | Level 6
2385488 | Level 6
2386876 | Level 6
2386903 | Level 6
2386905 | Level 6
2387151 | Level 6
2393308 | Level 2
2393433 | Level 2
2393553 | Level 2
2393678 | Level 2
2405945 | Level 2
2406074 | Level 2
2406676 | Level 2
2407480 | Level 2
2407528 | Level 2
2407530 | Level 2
2408607 | Level 2
2408648 | Level 2
2408650 | Level 2
2435802 | Level 6
2435924 | Level 6
2439108 | Level 6
2451220 | Level 2
2451447 | Level 6
2451544 | Nivel 1
2453177 | Nivel 1
2455298 | Level 6
2458928 | Level 2
2459090 | Level 2
2461160 | Level 2
2461167 | Level 2
2461367 | Level 2
2465390 | Level 2
2468814 | Nivel 1
2468976 | Nivel 1
2470502 | Nivel 1
2470507 | Nivel 1
2470666 | Nivel 1
2471067 | Nivel 1
2475204 | Level 6
2475786 | Level 6
2478293 | Level 6
2478300 | Level 6
2479119 | Level 6
2482356 | Level 6
2486476 | Level 2
2486478 | Level 2
2487030 | Level 2
2488788 | Level 2
2488790 | Level 2
2488817 | Level 2
2491266 | Level 2
2491268 | Level 2
2491339 | Level 2
2492796 | Level 2
2495381 | Level 2
2495481 | Level 2
2499903 | Nivel 1
2500015 | Nivel 1
2500090 | Nivel 1
2500092 | Nivel 1
2502148 | Nivel 1
2502755 | Nivel 1
2503272 | Nivel 1
2503274 | Nivel 1
2504821 | Nivel 1
2505398 | Nivel 1
2505400 | Nivel 1
2507892 | Nivel 1
2509532 | Nivel 1
2509534 | Nivel 1
2511059 | Level 6
2511131 | Level 6
2511696 | Level 6
2511723 | Level 6
2513792 | Level 6
2513794 | Level 6
2513878 | Level 6
2515389 | Level 6
2515484 | Level 6
2515486 | Level 6
2516534 | Level 6
2516559 | Level 6
2517150 | Level 6
2517152 | Level 6
2517206 | Level 6
2524010 | Level 2
2524337 | Level 2
2525185 | Level 2
2525187 | Level 2
2525708 | Level 2
2525710 | Level 2
2525733 | Nivel 4
2525736 | Level 2
2526284 | Level 2
2526287 | Level 2
2527957 | Level 2
2527960 | Level 2
2528269 | Level 2
2528701 | Level 2
2528818 | Level 2
2530850 | Level 2
2531325 | Level 2
2531327 | Level 2
2531942 | Level 2
2532377 | Level 2
2532479 | Level 2
2532799 | Level 2
2532802 | Level 2
2532986 | Level 2
2533124 | Level 2
2533127 | Level 2
2533129 | Level 2
2533131 | Level 2
2533510 | Level 2
2533513 | Level 2
2533701 | Level 2
2534123 | Level 2
2540849 | Level 2
2541186 | Level 2
2542070 | Level 2
2543009 | Nivel 4
2543513 | Level 2
2546905 | Level 2
2557430 | Level 2
2557999 | Level 2
2561323 | Level 2
2563427 | Level 2
2567870 | Level 2
2573210 | Level 2
2573213 | Level 2
2573421 | Level 2
2573423 | Level 2
2573956 | Nivel 1
2573958 | Level 2
2575529 | Level 2
2575532 | Level 2
2575608 | Level 2
2575651 | Level 2
2577526 | Level 2
2577529 | Level 2
2577711 | Level 2
2577762 | Level 2
2579598 | Nivel 1
2579600 | Nivel 1
2579645 | Nivel 1
2581089 | Level 6
2581092 | Level 6
2581261 | Level 6
2581288 | Level 6
2582902 | Nivel 1
2582905 | Nivel 1
2583081 | Nivel 1
2583105 | Nivel 1
2583108 | Nivel 1
2583139 | Level 6
2583142 | Level 6
2583202 | Level 6
2583204 | Level 6
2583233 | Level 6
2587190 | Nivel 1
2587199 | Nivel 1
2587532 | Nivel 1
2587534 | Nivel 1
2587559 | Nivel 1
2589531 | Level 6
2589534 | Level 6
2589771 | Level 6
2589807 | Level 6
2591309 | Level 6
2591312 | Level 6
2591526 | Level 6
2591528 | Level 6
2591562 | Level 6
2594029 | Nivel 1
2594032 | Nivel 1
2594263 | Nivel 1
2594324 | Nivel 1
2594326 | Nivel 1
2598224 | Level 2
2599068 | Level 2
2600871 | Level 2
2601038 | Level 2
2601067 | Level 2
2603452 | Level 2
2603455 | Level 2
2603504 | Level 2
2603506 | Level 2
2603531 | Level 2
2605017 | Level 2
2605020 | Level 2
2605089 | Level 2
2605091 | Level 2
2605110 | Level 2
2605112 | Level 2
2606641 | Level 2
2606644 | Level 2
2606711 | Level 2
2606713 | Level 2
2606735 | Level 2
2608275 | Level 2
2608278 | Level 2
2608357 | Level 2
2608359 | Level 2
2608381 | Level 2
2608383 | Level 2
2610508 | Nivel 1
2610511 | Nivel 1
2610514 | Nivel 1
2611075 | Nivel 1
2611107 | Nivel 1
2612441 | Nivel 1
2612444 | Nivel 1
2612530 | Nivel 1
2612561 | Nivel 1
2614482 | Nivel 1
2614485 | Nivel 1
2614564 | Nivel 1
2614587 | Nivel 1
2616190 | Nivel 1
2616311 | Nivel 1
2616319 | Nivel 1
2616322 | Nivel 1
2616424 | Nivel 1
2616447 | Nivel 1
2619280 | Level 6
2619283 | Level 6
2619365 | Level 6
2619395 | Level 6
2619416 | Level 6
2619419 | Level 6
2619507 | Level 6
2619532 | Level 6
2619560 | Level 6
2619563 | Level 6
2619664 | Level 6
2619689 | Level 6
2619717 | Level 6
2619720 | Level 6
2619807 | Level 6
2619836 | Level 6
2619910 | Level 2
2619913 | Level 2
2619988 | Level 2
2620013 | Level 2
2621451 | Level 2
2621454 | Level 2
2621509 | Level 2
2621512 | Level 2
2621556 | Level 2
2621559 | Level 2
2623031 | Level 2
2623034 | Level 2
2623085 | Level 2
2623127 | Level 2
2623130 | Level 2
2624707 | Nivel 1
2624710 | Nivel 1
2624833 | Nivel 1
2624858 | Nivel 1
2626128 | Nivel 1
2626131 | Nivel 1
2626253 | Nivel 1
2626256 | Nivel 1
2626295 | Nivel 1
2627683 | Nivel 1
2627686 | Nivel 1
2627787 | Nivel 1
2627790 | Nivel 1
2627832 | Nivel 1
2629212 | Nivel 1
2629215 | Nivel 1
2629317 | Nivel 1
2629319 | Nivel 1
2629362 | Nivel 1
2630932 | Level 6
2630935 | Level 6
2631041 | Level 6
2631044 | Level 6
2631075 | Level 6
2633108 | Level 6
2633111 | Level 6
2633180 | Level 6
2633183 | Level 6
2633226 | Level 6
2634672 | Level 6
2634675 | Level 6
2635258 | Level 6
2635261 | Level 6
2635302 | Level 6
2636771 | Level 6
2636774 | Level 6
2636850 | Level 6
2636853 | Level 6
2636896 | Level 6
2640705 | Level 2
2640714 | Level 2
2640964 | Level 2
2641820 | Level 2
2644116 | Level 2
2645949 | Level 2
2646562 | Level 2
2646655 | Level 2
2646832 | Level 2
2646865 | Level 2
2647887 | Level 2
2647889 | Level 2
2647971 | Level 2
2647973 | Level 2
2648003 | Level 2
2648026 | Level 2
2648034 | Level 2
2651875 | Level 2
2652587 | Level 2
2652590 | Level 2
2652656 | Level 2
2652659 | Level 2
2652709 | Level 2
2652731 | Level 2
2652753 | Level 2
2652776 | Level 2
2653698 | Level 2
2653816 | Level 2
2653827 | Level 2
2654046 | Level 2
2654118 | Level 2
2654393 | Level 2
2654405 | Level 2
2654524 | Level 2
2654527 | Level 2
2654530 | Level 2
2655048 | Level 2
2655050 | Level 2
2655078 | Level 2
2655143 | Level 2
2655145 | Level 2
2656406 | Level 2
2656409 | Level 2
2656412 | Level 2
2656440 | Level 2
2656443 | Level 2
2656446 | Level 2
2656521 | Level 2
2656523 | Level 2
2656693 | Level 2
2656695 | Level 2
2657691 | Nivel 1
2657694 | Nivel 1
2657907 | Nivel 1
2657910 | Nivel 1
2657959 | Nivel 1
2657986 | Nivel 1
2658006 | Nivel 1
2658027 | Nivel 1
2658844 | Nivel 1
2658847 | Nivel 1
2659140 | Nivel 1
2659143 | Nivel 1
2659187 | Nivel 1
2659214 | Nivel 1
2659254 | Nivel 1
2659277 | Nivel 1
2659891 | Nivel 1
2659894 | Nivel 1
2660099 | Nivel 1
2660102 | Nivel 1
2660153 | Nivel 1
2660174 | Nivel 1
2660201 | Nivel 1
2660232 | Nivel 1
2661363 | Nivel 1
2661366 | Nivel 1
2661389 | Nivel 1
2661392 | Nivel 1
2661437 | Nivel 1
2661458 | Nivel 1
2661483 | Nivel 1
2661512 | Nivel 1
2663462 | Level 6
2663465 | Level 6
2663491 | Level 6
2663494 | Level 6
2663619 | Level 6
2663642 | Level 6
2663673 | Level 6
2663696 | Level 6
2663858 | Level 6
2663861 | Level 6
2663987 | Level 6
2663990 | Level 6
2664045 | Level 6
2664067 | Level 6
2664120 | Level 6
2664145 | Level 6
2664894 | Level 6
2664897 | Level 6
2665013 | Level 6
2665016 | Level 6
2665087 | Level 6
2665108 | Level 6
2665131 | Level 6
2665154 | Level 6
2665467 | Level 6
2665470 | Level 6
2665600 | Level 6
2665603 | Level 6
2665775 | Level 6
2665797 | Level 6
2665820 | Level 6
2665843 | Level 6
2666168 | Level 6
2666171 | Level 6
2666263 | Level 6
2666265 | Level 6
2666319 | Level 6
2666321 | Level 6
2668271 | Level 2
2668274 | Level 2
2668393 | Level 2
2668396 | Level 2
2668488 | Level 2
2668490 | Level 2
2668525 | Level 2
2668527 | Level 2
2668660 | Level 2
2668662 | Level 2
2668687 | Level 2
2668689 | Level 2
2669140 | Level 2
2669142 | Level 2
2669255 | Level 2
2669257 | Level 2
2669396 | Level 2
2669398 | Level 2
2669832 | Level 2
2669834 | Level 2
2669906 | Level 2
2669908 | Level 2
2669951 | Level 2
2669953 | Level 2
2669974 | Level 2
