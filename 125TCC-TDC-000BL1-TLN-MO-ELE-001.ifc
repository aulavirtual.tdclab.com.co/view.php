Properties of the parts of a building model (IFC4), part 3 of 18

# IfcCableCarrierSegment: Conduit with Fittings:PVC (4616)
Name (Conduit with Fittings:PVC:...) | In | Length (m) | CrossSectionArea (m2) | OuterSurfaceArea (m2)
1540717 | Level 2 | 1.34711 | 0.000261727 | 0.0772618
1540883 | Level 2 | 0.2426 | 0.000261727 | 0.013914
1540984 | Level 2 | 1.548 | 0.000261727 | 0.0887836
1541144 | Level 2 | 1.0472 | 0.000261727 | 0.0600608
1541715 | Level 2 | 0.26665 | 0.000261727 | 0.0152934
1541716 | Level 2 | 0.2426 | 0.000261727 | 0.013914
1541717 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1541719 | Level 2 | 1.15507 | 0.000261727 | 0.0662473
1541720 | Level 2 | 0.805065 | 0.000261727 | 0.0461735
1541721 | Level 2 | 0.7926 | 0.000261727 | 0.0454585
1541722 | Level 2 | 2.4836 | 0.000261727 | 0.142444
1541724 | Level 2 | 1.8555 | 0.000261727 | 0.10642
1541725 | Level 2 | 0.615816 | 0.000261727 | 0.0353193
1541727 | Level 2 | 0.998002 | 0.000261727 | 0.0572391
1541728 | Level 2 | 0.448 | 0.000261727 | 0.0256945
1541729 | Level 2 | 0.249509 | 0.000261727 | 0.0143103
1541730 | Level 2 | 0.249509 | 0.000261727 | 0.0143103
1541732 | Level 2 | 0.65457 | 0.000261727 | 0.037542
1541735 | Level 2 | 0.40997 | 0.000261717 | 0.0235133
1541738 | Level 2 | 0.998002 | 0.000261727 | 0.0572391
1541739 | Level 2 | 0.048 | 0.000261727 | 0.00275298
1541740 | Level 2 | 0.102605 | 0.000261727 | 0.00588477
1541744 | Level 2 | 0.7926 | 0.000261727 | 0.0454585
1541750 | Level 2 | 0.0408049 | 0.000261727 | 0.00234031
1541751 | Level 2 | 0.249509 | 0.000261727 | 0.0143103
1541752 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1541753 | Level 2 | 0.626111 | 0.000261727 | 0.0359098
1541754 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1541755 | Level 2 | 1.09265 | 0.000261727 | 0.0626675
1541760 | Level 2 | 0.834668 | 0.000261727 | 0.0478713
1541761 | Level 2 | 0.7555 | 0.000261727 | 0.0433307
1541764 | Level 2 | 2.1564 | 0.000261727 | 0.123678
1541765 | Level 2 | 0.216402 | 0.000261727 | 0.0124114
1541768 | Level 2 | 0.68489 | 0.000261717 | 0.039281
1541770 | Level 2 | 2.70501 | 0.000261727 | 0.155142
1541771 | Level 2 | 1.40806 | 0.000261727 | 0.0807573
1541772 | Level 2 | 0.589 | 0.000261727 | 0.0337813
1541773 | Level 2 | 0.375751 | 0.000261727 | 0.0215507
1541781 | Level 2 | 0.00472433 | 0.000261727 | 0.000270958
1541786 | Level 2 | 1.11391 | 0.000261727 | 0.063887
1541789 | Level 2 | 0.410472 | 0.000261727 | 0.0235421
1541790 | Level 2 | 0.257522 | 0.000261727 | 0.0147699
1541799 | Level 2 | 1.8475 | 0.000261727 | 0.105961
1541812 | Level 2 | 0.22955 | 0.000261727 | 0.0131655
1541813 | Level 2 | 0.22955 | 0.000261727 | 0.0131655
1541814 | Level 2 | 0.7555 | 0.000261727 | 0.0433307
1541815 | Level 2 | 3.4773 | 0.000261727 | 0.199436
1541816 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1541825 | Level 2 | 0.249509 | 0.000261727 | 0.0143103
1541826 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1541829 | Level 2 | 1.89951 | 0.000261727 | 0.108944
1541830 | Level 2 | 1.8555 | 0.000261727 | 0.10642
1541833 | Level 2 | 0.2055 | 0.000261727 | 0.0117862
1541834 | Level 2 | 0.1597 | 0.000261727 | 0.00915939
1541841 | Level 2 | 0.707362 | 0.000261727 | 0.0405698
1541863 | Level 2 | 0.565825 | 0.000261727 | 0.0324522
1541870 | Level 2 | 0.0873247 | 0.000261717 | 0.00500839
1541875 | Level 2 | 0.0892176 | 0.000261727 | 0.00511696
1541883 | Level 2 | 0.1713 | 0.000261727 | 0.00982469
1541902 | Level 2 | 0.158503 | 0.000261727 | 0.00909073
1541920 | Level 2 | 0.992602 | 0.000261727 | 0.0569294
1541921 | Level 2 | 0.0071768
1541924 | Level 2 | 0.204702 | 0.000261727 | 0.0117404
1541926 | Level 2 | 0.2175 | 0.000261727 | 0.0124744
1541931 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1541932 | Level 2 | 0.05 | 0.000261727 | 0.00286769
1541935 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1541938 | Level 2 | 0.105944 | 0.000261727 | 0.00607629
1541947 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1541948 | Level 2 | 0.0234188 | 0.000261727 | 0.00134315
1541951 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1541954 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1541955 | Level 2 | 0.0234188 | 0.000261727 | 0.00134315
1541958 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
1541961 | Level 2 | 0.14381 | 0.000261727 | 0.00824803
1541968 | Level 2 | 1.76696 | 0.000261727 | 0.101342
1542014 | Level 2 | 0.249509 | 0.000261727 | 0.0143103
1542017 | Level 2 | 1.548 | 0.000261727 | 0.0887836
1542021 | Level 2 | 0.629881 | 0.000261727 | 0.036126
1542250 | Level 2 | 0.633995 | 0.000261727 | 0.036362
1542252 | Level 2 | 1.0472 | 0.000261727 | 0.0600607
1542604 | Level 2 | 0.285497 | 0.000261727 | 0.0163743
1543395 | Level 2 | 6.13685 | 0.00242431 | 1.07122
1543539 | Level 2 | 6.1574 | 0.00155156 | 0.859843
1543581 | Level 2 | 6.13685 | 0.00242431 | 1.07122
1554323 | Nivel 1 | 0.279115 | 0.000261727 | 0.0160083
1554324 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1554325 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1554326 | Nivel 1 | 0.0229341 | 0.000261727 | 0.00131535
1554327 | Nivel 1 | 1.15457 | 0.000261727 | 0.0662188
1554328 | Nivel 1 | 0.804569 | 0.000261727 | 0.046145
1554329 | Nivel 1 | 0.804569 | 0.000261727 | 0.046145
1554330 | Nivel 1 | 2.51533 | 0.000261717 | 0.144263
1554332 | Nivel 1 | 1.8555 | 0.000261727 | 0.10642
1554333 | Nivel 1 | 0.615816 | 0.000261727 | 0.0353193
1554335 | Nivel 1 | 0.998002 | 0.000261727 | 0.0572391
1554336 | Nivel 1 | 0.448 | 0.000261727 | 0.0256945
1554337 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1554338 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1554340 | Nivel 1 | 0.668585 | 0.000261727 | 0.0383458
1554341 | Nivel 1 | 1.51706 | 0.000261727 | 0.0870088
1554343 | Nivel 1 | 0.441527 | 0.000261727 | 0.0253232
1554346 | Nivel 1 | 1.048 | 0.000261727 | 0.0601068
1554348 | Nivel 1 | 0.1026 | 0.000261727 | 0.00588449
1554352 | Nivel 1 | 0.7926 | 0.000261727 | 0.0454585
1554353 | Nivel 1 | 0.767057 | 0.000261727 | 0.0439936
1554354 | Nivel 1 | 0.296722 | 0.000261727 | 0.0170181
1554355 | Nivel 1 | 0.0229379 | 0.000261727 | 0.00131557
1554358 | Nivel 1 | 0.0408 | 0.000261727 | 0.00234003
1554359 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1554360 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1554361 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1554362 | Nivel 1 | 0.631383 | 0.000261727 | 0.0362121
1554363 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1554365 | Nivel 1 | 0.0142587 | 0.000261727 | 0.000817789
1554370 | Nivel 1 | 0.804569 | 0.000261727 | 0.046145
1554371 | Nivel 1 | 0.767057 | 0.000261727 | 0.0439936
1554374 | Nivel 1 | 2.1564 | 0.000261727 | 0.123678
1554375 | Nivel 1 | 0.166402 | 0.000261727 | 0.00954375
1554378 | Nivel 1 | 0.17942 | 0.000261727 | 0.0102904
1554379 | Nivel 1 | 0.941555 | 0.000261727 | 0.0540017
1554380 | Nivel 1 | 2.69157 | 0.000261727 | 0.154372
1554382 | Nivel 1 | 1.3965 | 0.000261727 | 0.0800944
1554383 | Nivel 1 | 0.589 | 0.000261727 | 0.0337813
1554385 | Nivel 1 | 0.403493 | 0.000261717 | 0.0231418
1554391 | Nivel 1 | 0.012888 | 0.000261727 | 0.000739177
1554392 | Nivel 1 | 0.368727 | 0.000261727 | 0.0211479
1554393 | Nivel 1 | 0.0131379 | 0.000261727 | 0.000753508
1554398 | Nivel 1 | 1.11439 | 0.000445281 | 0.0833666
1554399 | Nivel 1 | 0.0080556 | 0.000445281 | 0.000602633
1554402 | Nivel 1 | 1.23982 | 0.000445265 | 0.0927499
1554403 | Nivel 1 | 0.241107 | 0.000261727 | 0.0138284
1554404 | Nivel 1 | 6.5806 | 0.000445281 | 0.492289
1554405 | Nivel 1 | 0.20485 | 0.000445265 | 0.0153247
1554406 | Nivel 1 | 0.21185 | 0.000445281 | 0.0158483
1554407 | Nivel 1 | 0.60432 | 0.000445281 | 0.0452087
1554408 | Nivel 1 | 2.96223 | 0.000445281 | 0.221602
1554409 | Nivel 1 | 1.35839 | 0.000261727 | 0.0779089
1554411 | Nivel 1 | 1.11391 | 0.000261727 | 0.063887
1554415 | Nivel 1 | 0.324805 | 0.000261727 | 0.0186288
1554417 | Nivel 1 | 0.173109 | 0.000261727 | 0.00992845
1554421 | Nivel 1 | 0.0507798 | 0.000261727 | 0.00291241
1554426 | Nivel 1 | 1.8475 | 0.000261727 | 0.105961
1554434 | Nivel 1 | 1.548 | 0.000261727 | 0.0887836
1554436 | Nivel 1 | 0.4 | 0.000261727 | 0.0229415
1554441 | Nivel 1 | 0.391107 | 0.000261727 | 0.0224314
1554442 | Nivel 1 | 0.241107 | 0.000261727 | 0.0138284
1554443 | Nivel 1 | 0.767057 | 0.000261727 | 0.0439936
1554444 | Nivel 1 | 3.49886 | 0.000261727 | 0.200672
1554445 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1554455 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1554460 | Nivel 1 | 1.95457 | 0.000261727 | 0.112102
1554461 | Nivel 1 | 1.9055 | 0.000261727 | 0.109288
1554462 | Nivel 1 | 0.6355 | 0.000261727 | 0.0364483
1554463 | Nivel 1 | 1.09862 | 0.000261727 | 0.0630099
1554464 | Nivel 1 | 0.0174379 | 0.000261727 | 0.00100013
1554466 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1554467 | Nivel 1 | 0.171257 | 0.000261727 | 0.00982222
1554474 | Nivel 1 | 0.0229379 | 0.000261727 | 0.00131557
1554475 | Nivel 1 | 0.273138 | 0.000261727 | 0.0156655
1554485 | Nivel 1 | 0.201138 | 0.000261727 | 0.011536
1554501 | Nivel 1 | 0.657257 | 0.000261727 | 0.0376961
1554512 | Nivel 1 | 0.097445 | 0.000261727 | 0.00558883
1554517 | Nivel 1 | 0.0843352 | 0.000261727 | 0.00483694
1554524 | Nivel 1 | 0.727458 | 0.000261727 | 0.0417224
1554526 | Nivel 1 | 0.182857 | 0.000261727 | 0.0104875
1554536 | Nivel 1 | 1.14894 | 0.000261727 | 0.0658962
1554546 | Nivel 1 | 0.158503 | 0.000261727 | 0.00909073
1554557 | Nivel 1 | 0.202183 | 0.000261727 | 0.011596
1554584 | Nivel 1 | 1.93491 | 0.000261727 | 0.110974
1554585 | Nivel 1 | 0.424815 | 0.000261717 | 0.0243647
1554610 | Nivel 1 | 0.00269577 | 0.000445281 | 0.000201668
1554611 | Nivel 1 | 0.0179324 | 0.000445281 | 0.00134151
1554614 | Nivel 1 | 0.00269577 | 0.000445281 | 0.000201668
1554617 | Nivel 1 | 2.23222 | 0.000445281 | 0.16699
1554626 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1554627 | Nivel 1 | 0.0875 | 0.000261727 | 0.00501845
1554630 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1554633 | Nivel 1 | 0.563915 | 0.000261727 | 0.0323426
1554652 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1554653 | Nivel 1 | 0.0179324 | 0.000261727 | 0.00102849
1554656 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1554659 | Nivel 1 | 0.291829 | 0.000261727 | 0.0167375
1554668 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1554669 | Nivel 1 | 0.0234188 | 0.000261727 | 0.00134315
1554672 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1554675 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1554676 | Nivel 1 | 0.0234188 | 0.000261727 | 0.00134315
1554679 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1554682 | Nivel 1 | 0.14887 | 0.000261727 | 0.00853825
1554691 | Nivel 1 | 1.75852 | 0.000261727 | 0.100858
1554949 | Nivel 1 | 0.278619 | 0.000261727 | 0.0159798
1554950 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1554951 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1554952 | Nivel 1 | 0.0164369 | 0.000261717 | 0.000942715
1554953 | Nivel 1 | 1.15457 | 0.000261727 | 0.0662188
1554954 | Nivel 1 | 0.804569 | 0.000261727 | 0.046145
1554955 | Nivel 1 | 0.804569 | 0.000261727 | 0.046145
1554956 | Nivel 1 | 2.52633 | 0.000261727 | 0.144894
1554958 | Nivel 1 | 1.8555 | 0.000261727 | 0.10642
1554959 | Nivel 1 | 0.615816 | 0.000261727 | 0.0353193
1554961 | Nivel 1 | 0.998002 | 0.000261727 | 0.0572391
1554962 | Nivel 1 | 0.448 | 0.000261727 | 0.0256945
1554963 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1554964 | Nivel 1 | 0.2426 | 0.000261727 | 0.013914
1554966 | Nivel 1 | 0.66863 | 0.000261727 | 0.0383484
1554967 | Nivel 1 | 1.50553 | 0.000261727 | 0.0863477
1554969 | Nivel 1 | 0.42997 | 0.000261717 | 0.0246603
1554972 | Nivel 1 | 0.998002 | 0.000261727 | 0.0572391
1554973 | Nivel 1 | 0.048 | 0.000261727 | 0.00275298
1554974 | Nivel 1 | 0.1026 | 0.000261727 | 0.00588449
1554978 | Nivel 1 | 0.804569 | 0.000261717 | 0.046145
1554979 | Nivel 1 | 0.7555 | 0.000261727 | 0.0433307
1554980 | Nivel 1 | 0.296722 | 0.000261727 | 0.0170181
1554984 | Nivel 1 | 0.0408 | 0.000261727 | 0.00234003
1554985 | Nivel 1 | 0.254619 | 0.000261727 | 0.0146033
1554986 | Nivel 1 | 0.2055 | 0.000261727 | 0.0117862
1554988 | Nivel 1 | 0.2055 | 0.000261727 | 0.0117862
1554990 | Nivel 1 | 0.0142587 | 0.000261727 | 0.000817789
1554994 | Nivel 1 | 0.824569 | 0.000261727 | 0.0472921
1554995 | Nivel 1 | 0.7555 | 0.000261727 | 0.0433307
1554998 | Nivel 1 | 2.1564 | 0.000261727 | 0.123678
1554999 | Nivel 1 | 0.216402 | 0.000261727 | 0.0124114
1555002 | Nivel 1 | 0.679625 | 0.000261717 | 0.038979
1555003 | Nivel 1 | 0.941552 | 0.000261727 | 0.0540015
1555004 | Nivel 1 | 2.74157 | 0.000261717 | 0.157239
1555005 | Nivel 1 | 1.3965 | 0.000261727 | 0.0800944
1555006 | Nivel 1 | 0.589 | 0.000261727 | 0.0337813
1555007 | Nivel 1 | 0.405071 | 0.000261727 | 0.0232323
1555013 | Nivel 1 | 0.00571991 | 0.000261727 | 0.000328058
1555015 | Nivel 1 | 0.0175129 | 0.000261727 | 0.00100443
1555020 | Nivel 1 | 1.10235 | 0.000261727 | 0.0632241
1555023 | Nivel 1 | 0.443274 | 0.000261727 | 0.0254234
1555024 | Nivel 1 | 0.243454 | 0.000261727 | 0.013963
1555025 | Nivel 1 | 0.106348 | 0.000261727 | 0.00609945
1555033 | Nivel 1 | 1.8475 | 0.000261727 | 0.105961
1555041 | Nivel 1 | 0.4481 | 0.000261727 | 0.0257002
1555046 | Nivel 1 | 0.391107 | 0.000261727 | 0.0224314
1555047 | Nivel 1 | 0.32955 | 0.000261727 | 0.0189009
1555048 | Nivel 1 | 0.7555 | 0.000261727 | 0.0433307
1555049 | Nivel 1 | 3.4873 | 0.000261727 | 0.20001
1555050 | Nivel 1 | 0.2055 | 0.000261727 | 0.0117862
1555059 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1555060 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1555063 | Nivel 1 | 1.90457 | 0.000261727 | 0.109234
1555064 | Nivel 1 | 1.86706 | 0.000261727 | 0.107083
1555066 | Nivel 1 | 0.022438 | 0.000261727 | 0.0012869
1555067 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1555068 | Nivel 1 | 0.171257 | 0.000261727 | 0.00982222
1555075 | Nivel 1 | 0.0119369 | 0.000261727 | 0.000684623
1555083 | Nivel 1 | 0.188638 | 0.000261727 | 0.0108191
1555097 | Nivel 1 | 0.6457 | 0.000261727 | 0.0370333
1555104 | Nivel 1 | 0.0635071 | 0.000261717 | 0.00364236
1555109 | Nivel 1 | 0.0893379 | 0.000261727 | 0.00512386
1555117 | Nivel 1 | 0.182857 | 0.000261727 | 0.0104875
1555136 | Nivel 1 | 0.158503 | 0.000261727 | 0.00909073
1555146 | Nivel 1 | 0.190632 | 0.000261727 | 0.0109334
1555165 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555166 | Nivel 1 | 0.05 | 0.000261727 | 0.00286769
1555169 | Nivel 1 | 0.00450539 | 0.000261727 | 0.000258401
1555172 | Nivel 1 | 0.112766 | 0.000261727 | 0.00646757
1555181 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555182 | Nivel 1 | 0.0234188 | 0.000261727 | 0.00134315
1555185 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555188 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555189 | Nivel 1 | 0.0234188 | 0.000261727 | 0.00134315
1555192 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555195 | Nivel 1 | 0.136901 | 0.000261727 | 0.00785178
1555202 | Nivel 1 | 1.74696 | 0.000261727 | 0.100195
1555215 | Nivel 1 | 0.297059 | 0.000261727 | 0.0170374
1555217 | Nivel 1 | 0.645459 | 0.000261727 | 0.0370195
1555251 | Nivel 1 | 1.11439 | 0.000445281 | 0.0833665
1555252 | Nivel 1 | 0.00680491 | 0.000445281 | 0.00050907
1555255 | Nivel 1 | 1.23982 | 0.000445265 | 0.0927499
1555256 | Nivel 1 | 6.57935 | 0.000445281 | 0.492196
1555257 | Nivel 1 | 0.21185 | 0.000445281 | 0.0158483
1555258 | Nivel 1 | 0.21185 | 0.000445281 | 0.0158483
1555259 | Nivel 1 | 0.0678648 | 0.000445281 | 0.00507691
1555260 | Nivel 1 | 2.58923 | 0.000445281 | 0.193698
1555261 | Nivel 1 | 2.6201 | 0.000261727 | 0.150273
1555264 | Nivel 1 | 2.46321 | 0.000261727 | 0.141274
1555265 | Nivel 1 | 0.424815 | 0.000261717 | 0.0243647
1555270 | Nivel 1 | 0.00269577 | 0.000445281 | 0.000201668
1555271 | Nivel 1 | 0.0179324 | 0.000445281 | 0.00134151
1555274 | Nivel 1 | 0.00269577 | 0.000445281 | 0.000201668
1555277 | Nivel 1 | 2.23222 | 0.000445281 | 0.16699
1555286 | Nivel 1 | 0.0267463 | 0.000261727 | 0.001534
1555287 | Nivel 1 | 0.2 | 0.000261727 | 0.0114707
1555290 | Nivel 1 | 0.00450508 | 0.000261727 | 0.000258383
1555293 | Nivel 1 | 0.0177292 | 0.000261727 | 0.00101684
1555296 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555297 | Nivel 1 | 0.0179324 | 0.000261727 | 0.00102849
1555300 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555303 | Nivel 1 | 0.291829 | 0.000261717 | 0.0167375
1555316 | Nivel 1 | 0.241107 | 0.000261727 | 0.0138284
1555317 | Nivel 1 | 1.35839 | 0.000261727 | 0.0779089
1555325 | Nivel 1 | 1.11439 | 0.000445281 | 0.0833666
1555326 | Nivel 1 | 0.0068056 | 0.000445281 | 0.000509121
1555329 | Nivel 1 | 1.23982 | 0.000445281 | 0.0927499
1555330 | Nivel 1 | 6.58189 | 0.000445281 | 0.492386
1555331 | Nivel 1 | 0.20739 | 0.000445281 | 0.0155147
1555332 | Nivel 1 | 0.21439 | 0.000445281 | 0.0160383
1555333 | Nivel 1 | 0.123129 | 0.000445281 | 0.00921119
1555338 | Nivel 1 | 2.40387 | 0.000261727 | 0.137871
1555339 | Nivel 1 | 0.424815 | 0.000261717 | 0.0243647
1555342 | Nivel 1 | 0.00269577 | 0.000445281 | 0.000201668
1555343 | Nivel 1 | 0.0179324 | 0.000445281 | 0.00134151
1555346 | Nivel 1 | 0.00269577 | 0.000445281 | 0.000201668
1555349 | Nivel 1 | 2.23222 | 0.000445281 | 0.16699
1555358 | Nivel 1 | 0.0144049 | 0.000261727 | 0.000826173
1555359 | Nivel 1 | 0.2 | 0.000261727 | 0.0114707
1555362 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555365 | Nivel 1 | 0.017729 | 0.000261727 | 0.00101682
1555368 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555369 | Nivel 1 | 0.0179324 | 0.000261727 | 0.00102849
1555372 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555375 | Nivel 1 | 0.291829 | 0.000261717 | 0.0167375
1555390 | Nivel 1 | 0.241107 | 0.000261727 | 0.0138284
1555391 | Nivel 1 | 1.35867 | 0.000261727 | 0.0779247
1555394 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1555397 | Nivel 1 | 1.548 | 0.000261727 | 0.0887836
1555400 | Nivel 1 | 1.04706 | 0.000261727 | 0.0600526
1555439 | Nivel 1 | 0.278619 | 0.000261727 | 0.0159798
1555440 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1555441 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1555442 | Nivel 1 | 0.0214432 | 0.000261727 | 0.00122985
1555443 | Nivel 1 | 1.15457 | 0.000261727 | 0.0662188
1555446 | Nivel 1 | 2.52133 | 0.000261727 | 0.144607
1555448 | Nivel 1 | 1.8555 | 0.000261727 | 0.10642
1555449 | Nivel 1 | 0.615816 | 0.000261727 | 0.0353193
1555451 | Nivel 1 | 0.85 | 0.000261727 | 0.0487506
1555452 | Nivel 1 | 0.335 | 0.000261727 | 0.0192135
1555453 | Nivel 1 | 0.195569 | 0.000261727 | 0.0112166
1555454 | Nivel 1 | 0.205569 | 0.000261727 | 0.0117901
1555456 | Nivel 1 | 0.639628 | 0.000261727 | 0.036685
1555457 | Nivel 1 | 1.51185 | 0.000261727 | 0.0867102
1555459 | Nivel 1 | 0.441527 | 0.000261717 | 0.0253232
1555462 | Nivel 1 | 1.048 | 0.000261727 | 0.0601068
1555464 | Nivel 1 | 0.102605 | 0.000261727 | 0.00588477
1555468 | Nivel 1 | 0.805 | 0.000261727 | 0.0461697
1555469 | Nivel 1 | 0.767058 | 0.000261727 | 0.0439936
1555470 | Nivel 1 | 0.296722 | 0.000261727 | 0.0170181
1555471 | Nivel 1 | 0.0169364 | 0.000261717 | 0.000971367
1555474 | Nivel 1 | 0.0408049 | 0.000261722 | 0.00234031
1555475 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1555476 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1555477 | Nivel 1 | 0.631374 | 0.000261727 | 0.0362116
1555478 | Nivel 1 | 0.1465 | 0.000261727 | 0.00840232
1555479 | Nivel 1 | 1.06711 | 0.000261727 | 0.0612025
1555480 | Nivel 1 | 0.0142587 | 0.000261727 | 0.000817789
1555484 | Nivel 1 | 0.824569 | 0.000261727 | 0.0472921
1555485 | Nivel 1 | 0.767057 | 0.000261727 | 0.0439936
1555488 | Nivel 1 | 2.1564 | 0.000261727 | 0.123678
1555489 | Nivel 1 | 0.216402 | 0.000261727 | 0.0124114
1555492 | Nivel 1 | 0.71239 | 0.000261717 | 0.0408582
1555493 | Nivel 1 | 0.941552 | 0.000261727 | 0.0540015
1555494 | Nivel 1 | 2.74157 | 0.000261717 | 0.157239
1555495 | Nivel 1 | 1.40806 | 0.000261727 | 0.0807573
1555496 | Nivel 1 | 0.589 | 0.000261727 | 0.0337813
1555497 | Nivel 1 | 0.43414 | 0.000261727 | 0.0248995
1555503 | Nivel 1 | 0.0103879 | 0.000261727 | 0.000595785
1555504 | Nivel 1 | 0.365602 | 0.000261727 | 0.0209686
1555505 | Nivel 1 | 0.0338912 | 0.000261727 | 0.00194379
1555510 | Nivel 1 | 1.11391 | 0.000261727 | 0.063887
1555513 | Nivel 1 | 0.310436 | 0.000261727 | 0.0178046
1555514 | Nivel 1 | 0.187113 | 0.000261727 | 0.0107316
1555516 | Nivel 1 | 0.0523645 | 0.000261727 | 0.0030033
1555521 | Nivel 1 | 1.8475 | 0.000261727 | 0.105961
1555529 | Nivel 1 | 0.4481 | 0.000261727 | 0.0257002
1555534 | Nivel 1 | 0.391107 | 0.000261727 | 0.0224314
1555535 | Nivel 1 | 0.241107 | 0.000261727 | 0.0138284
1555536 | Nivel 1 | 0.767057 | 0.000261727 | 0.0439936
1555537 | Nivel 1 | 3.49886 | 0.000261727 | 0.200672
1555538 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1555548 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1555551 | Nivel 1 | 1.90457 | 0.000261727 | 0.109234
1555552 | Nivel 1 | 1.8555 | 0.000261727 | 0.10642
1555553 | Nivel 1 | 1.22362 | 0.000261727 | 0.0701791
1555554 | Nivel 1 | 0.0124377 | 0.000261727 | 0.000713349
1555555 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1555556 | Nivel 1 | 0.171257 | 0.000261727 | 0.00982222
1555563 | Nivel 1 | 0.0169369 | 0.000261727 | 0.000971391
1555564 | Nivel 1 | 0.258138 | 0.000261727 | 0.0148052
1555571 | Nivel 1 | 0.188638 | 0.000261727 | 0.0108191
1555585 | Nivel 1 | 0.657257 | 0.000261727 | 0.0376961
1555592 | Nivel 1 | 0.092445 | 0.000261717 | 0.00530206
1555597 | Nivel 1 | 0.0968611 | 0.000261727 | 0.00555534
1555605 | Nivel 1 | 0.182857 | 0.000261727 | 0.0104875
1555624 | Nivel 1 | 0.158503 | 0.000261727 | 0.00909073
1555651 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555652 | Nivel 1 | 0.085 | 0.000261727 | 0.00487506
1555655 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555658 | Nivel 1 | 0.0334442 | 0.000261727 | 0.00191815
1555667 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555668 | Nivel 1 | 0.0234188 | 0.000261727 | 0.00134315
1555671 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555674 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555675 | Nivel 1 | 0.0234188 | 0.000261727 | 0.00134315
1555678 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1555681 | Nivel 1 | 0.14887 | 0.000261727 | 0.00853825
1555688 | Nivel 1 | 1.74696 | 0.000261727 | 0.100195
1555701 | Nivel 1 | 0.254567 | 0.000261727 | 0.0146003
1555704 | Nivel 1 | 1.548 | 0.000261727 | 0.0887836
1555738 | Nivel 1 | 0.645457 | 0.000261727 | 0.0370193
1555740 | Nivel 1 | 1.0355 | 0.000261727 | 0.0593897
1555747 | Nivel 1 | 0.2855 | 0.000261727 | 0.0163745
1556165 | Nivel 1 | 0.278619 | 0.000261727 | 0.0159798
1556166 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1556167 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1556168 | Nivel 1 | 0.027438 | 0.000261727 | 0.00157367
1556169 | Nivel 1 | 1.15457 | 0.000261717 | 0.0662188
1556170 | Nivel 1 | 0.804568 | 0.000261727 | 0.046145
1556171 | Nivel 1 | 0.804568 | 0.000261727 | 0.046145
1556172 | Nivel 1 | 2.56284 | 0.000261717 | 0.146988
1556174 | Nivel 1 | 1.8555 | 0.000261727 | 0.10642
1556175 | Nivel 1 | 0.615816 | 0.000261727 | 0.0353193
1556177 | Nivel 1 | 1.048 | 0.000261727 | 0.0601068
1556178 | Nivel 1 | 0.448 | 0.000261727 | 0.0256945
1556179 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1556180 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1556182 | Nivel 1 | 0.653897 | 0.000261727 | 0.0375034
1556183 | Nivel 1 | 1.51705 | 0.000261727 | 0.0870082
1556185 | Nivel 1 | 0.441527 | 0.000261717 | 0.0253232
1556188 | Nivel 1 | 0.998002 | 0.000261717 | 0.0572391
1556190 | Nivel 1 | 0.102603 | 0.000261727 | 0.00588469
1556197 | Nivel 1 | 0.0129369 | 0.000261717 | 0.000741977
1556200 | Nivel 1 | 0.0408183 | 0.000261727 | 0.00234108
1556201 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1556202 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1556203 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1556205 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1556207 | Nivel 1 | 0.0142642 | 0.000261727 | 0.000818107
1556212 | Nivel 1 | 0.824569 | 0.000261727 | 0.0472921
1556213 | Nivel 1 | 0.7555 | 0.000261727 | 0.0433307
1556216 | Nivel 1 | 2.1564 | 0.000261727 | 0.123678
1556217 | Nivel 1 | 0.216402 | 0.000261727 | 0.0124114
1556220 | Nivel 1 | 0.18442 | 0.000261727 | 0.0105772
1556221 | Nivel 1 | 0.941552 | 0.000261727 | 0.0540015
1556222 | Nivel 1 | 2.69157 | 0.000261727 | 0.154372
1556224 | Nivel 1 | 1.40806 | 0.000261727 | 0.0807573
1556225 | Nivel 1 | 0.589 | 0.000261727 | 0.0337813
1556227 | Nivel 1 | 0.429721 | 0.000261727 | 0.0246461
1556234 | Nivel 1 | 0.362602 | 0.000261727 | 0.0207966
1556235 | Nivel 1 | 0.0188879 | 0.000261727 | 0.00108329
1556240 | Nivel 1 | 1.10236 | 0.000261727 | 0.0632243
1556244 | Nivel 1 | 0.431477 | 0.000261727 | 0.0247468
1556246 | Nivel 1 | 0.243258 | 0.000261727 | 0.0139517
1556255 | Nivel 1 | 1.8475 | 0.000261727 | 0.105961
1556262 | Nivel 1 | 1.548 | 0.000261727 | 0.0887836
1556264 | Nivel 1 | 0.4481 | 0.000261727 | 0.0257002
1556269 | Nivel 1 | 0.391107 | 0.000261727 | 0.0224314
1556270 | Nivel 1 | 0.241107 | 0.000261727 | 0.0138284
1556271 | Nivel 1 | 0.7555 | 0.000261727 | 0.0433307
1556272 | Nivel 1 | 3.49886 | 0.000261727 | 0.200672
1556273 | Nivel 1 | 0.217057 | 0.000261727 | 0.012449
1556286 | Nivel 1 | 1.90457 | 0.000261727 | 0.109234
1556287 | Nivel 1 | 1.8555 | 0.000261727 | 0.10642
1556289 | Nivel 1 | 1.10942 | 0.000261727 | 0.0636293
1556290 | Nivel 1 | 0.017438 | 0.000261727 | 0.00100014
1556291 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
1556292 | Nivel 1 | 0.208769 | 0.000261727 | 0.0119737
1556299 | Nivel 1 | 0.704326 | 0.000261727 | 0.0403957
1556307 | Nivel 1 | 0.193638 | 0.000261727 | 0.0111059
1556321 | Nivel 1 | 0.657257 | 0.000261717 | 0.0376961
1556328 | Nivel 1 | 0.102445 | 0.000261727 | 0.0058756
1556333 | Nivel 1 | 0.0893379 | 0.000261727 | 0.00512386
1556341 | Nivel 1 | 0.182857 | 0.000261727 | 0.0104875
1556360 | Nivel 1 | 0.158503 | 0.000261727 | 0.00909073
1556370 | Nivel 1 | 0.202181 | 0.000261727 | 0.0115958
1556393 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1556394 | Nivel 1 | 0.075 | 0.000261727 | 0.00430153
1556397 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1556400 | Nivel 1 | 0.571415 | 0.000261727 | 0.0327727
1556409 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1556410 | Nivel 1 | 0.0234188 | 0.000261727 | 0.00134315
1556413 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1556416 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1556417 | Nivel 1 | 0.0234188 | 0.000261727 | 0.00134315
1556420 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1556423 | Nivel 1 | 0.14887 | 0.000261727 | 0.00853825
1556432 | Nivel 1 | 1.75852 | 0.000261727 | 0.100858
1556664 | Nivel 1 | 0.286521 | 0.000261727 | 0.0164331
1556666 | Nivel 1 | 0.6963 | 0.000261727 | 0.0399354
1557188 | Nivel 1 | 1.11439 | 0.000445281 | 0.0833666
1557189 | Nivel 1 | 0.00675666 | 0.000445281 | 0.00050546
1557192 | Nivel 1 | 1.23982 | 0.000445281 | 0.0927499
1557194 | Nivel 1 | 6.573 | 0.000445281 | 0.491721
1557195 | Nivel 1 | 0.1985 | 0.000445265 | 0.0148496
1557196 | Nivel 1 | 0.2055 | 0.000445281 | 0.0153733
1557197 | Nivel 1 | 0.599014 | 0.000445281 | 0.0448118
1557198 | Nivel 1 | 3.25912 | 0.000445281 | 0.243812
1557203 | Nivel 1 | 1.9333 | 0.000261727 | 0.110882
1557204 | Nivel 1 | 0.424815 | 0.000261727 | 0.0243647
1557211 | Nivel 1 | 0.00269577 | 0.000445281 | 0.000201668
1557212 | Nivel 1 | 0.0179324 | 0.000445281 | 0.00134151
1557215 | Nivel 1 | 0.00269577 | 0.000445281 | 0.000201668
1557218 | Nivel 1 | 2.23222 | 0.000445281 | 0.16699
1557227 | Nivel 1 | 0.0115765 | 0.000261727 | 0.000663952
1557228 | Nivel 1 | 0.2 | 0.000261727 | 0.0114707
1557231 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1557234 | Nivel 1 | 0.017729 | 0.000261727 | 0.00101682
1557237 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1557238 | Nivel 1 | 0.0179324 | 0.000261727 | 0.00102849
1557241 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
1557244 | Nivel 1 | 0.291829 | 0.000261727 | 0.0167375
1557337 | Nivel 1 | 0.241091 | 0.000261727 | 0.0138274
1557338 | Nivel 1 | 1.35873 | 0.000261727 | 0.0779281
1557830 | Nivel 1 | 2.94994 | 0.000261727 | 0.16919
1557881 | Nivel 1 | 2.90412 | 0.000445281 | 0.217255
1588593 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1588598 | Level 6 | 2.51806 | 0.000261717 | 0.14442
1588600 | Level 6 | 1.8555 | 0.000261727 | 0.10642
1588601 | Level 6 | 0.615816 | 0.000261727 | 0.0353193
1588603 | Level 6 | 0.998002 | 0.000261727 | 0.0572391
1588604 | Level 6 | 0.448 | 0.000261727 | 0.0256945
1588608 | Level 6 | 0.65457 | 0.000261727 | 0.037542
1588609 | Level 6 | 1.51704 | 0.000261727 | 0.0870079
1588611 | Level 6 | 0.441527 | 0.000261727 | 0.0253232
1588614 | Level 6 | 1.048 | 0.000261727 | 0.0601068
1588615 | Level 6 | 0.048 | 0.000261727 | 0.00275298
1588616 | Level 6 | 0.1026 | 0.000261727 | 0.00588449
1588621 | Level 6 | 0.7555 | 0.000261727 | 0.0433307
1588626 | Level 6 | 0.0408 | 0.000261727 | 0.00234003
1588628 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1588631 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1588632 | Level 6 | 1.06711 | 0.000261727 | 0.0612025
1588633 | Level 6 | 0.0143729 | 0.000261727 | 0.00082434
1588646 | Level 6 | 0.14319 | 0.000261727 | 0.00821247
1588648 | Level 6 | 2.69157 | 0.000261727 | 0.154372
1588650 | Level 6 | 1.3965 | 0.000261727 | 0.0800944
1588653 | Level 6 | 0.378823 | 0.000261717 | 0.0217269
1588666 | Level 6 | 1.11439 | 0.000445281 | 0.0833666
1588667 | Level 6 | 0.0080556 | 0.000445281 | 0.000602633
1588670 | Level 6 | 1.23982 | 0.000445265 | 0.0927499
1588671 | Level 6 | 0.241107 | 0.000261727 | 0.0138284
1588672 | Level 6 | 6.5806 | 0.000445281 | 0.492289
1588673 | Level 6 | 0.20485 | 0.000445265 | 0.0153247
1588674 | Level 6 | 0.21185 | 0.000445281 | 0.0158483
1588675 | Level 6 | 0.604304 | 0.000445281 | 0.0452075
1588676 | Level 6 | 2.96224 | 0.000445281 | 0.221602
1588677 | Level 6 | 1.35839 | 0.000261727 | 0.0779089
1588678 | Level 6 | 3.00181 | 0.000261727 | 0.172165
1588679 | Level 6 | 1.10235 | 0.000261727 | 0.0632241
1588682 | Level 6 | 0.2855 | 0.000261727 | 0.0163745
1588683 | Level 6 | 0.43171 | 0.000261727 | 0.0247602
1588685 | Level 6 | 0.257522 | 0.000261727 | 0.0147699
1588697 | Level 6 | 1.598 | 0.000261727 | 0.0916513
1588699 | Level 6 | 0.4481 | 0.000261727 | 0.0257002
1588705 | Level 6 | 0.241107 | 0.000261727 | 0.0138284
1588707 | Level 6 | 3.53591 | 0.000261727 | 0.202798
1588708 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1588723 | Level 6 | 1.90457 | 0.000261727 | 0.109234
1588724 | Level 6 | 1.86706 | 0.000261727 | 0.107083
1588725 | Level 6 | 0.647057 | 0.000261727 | 0.0371111
1588726 | Level 6 | 1.07862 | 0.000261727 | 0.0618628
1588727 | Level 6 | 0.014938 | 0.000261727 | 0.000856751
1588728 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1588729 | Level 6 | 0.171257 | 0.000261727 | 0.00982222
1588758 | Level 6 | 0.657257 | 0.000261727 | 0.0376961
1588778 | Level 6 | 0.178307 | 0.000261717 | 0.0102266
1588807 | Level 6 | 0.202184 | 0.000261717 | 0.011596
1588828 | Level 6 | 1.93492 | 0.000261727 | 0.110975
1588829 | Level 6 | 0.424815 | 0.000261717 | 0.0243647
1588838 | Level 6 | 0.00269577 | 0.000445281 | 0.000201668
1588839 | Level 6 | 0.0179324 | 0.000445281 | 0.00134151
1588842 | Level 6 | 0.00269577 | 0.000445281 | 0.000201668
1588845 | Level 6 | 2.23222 | 0.000445281 | 0.16699
1588854 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1588855 | Level 6 | 0.07 | 0.000261727 | 0.00401476
1588858 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1588861 | Level 6 | 0.58547 | 0.000261727 | 0.0335789
1588870 | Level 6 | 0.0144049 | 0.000261727 | 0.000826173
1588871 | Level 6 | 0.2 | 0.000261727 | 0.0114707
1588874 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1588877 | Level 6 | 0.017729 | 0.000261727 | 0.00101682
1588880 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1588881 | Level 6 | 0.0179324 | 0.000261727 | 0.00102849
1588884 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1588887 | Level 6 | 0.291829 | 0.000261727 | 0.0167375
1588896 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1588897 | Level 6 | 0.0234188 | 0.000261727 | 0.00134315
1588900 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1588919 | Level 6 | 1.75852 | 0.000261727 | 0.100858
1589003 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1589008 | Level 6 | 2.51806 | 0.000261727 | 0.14442
1589010 | Level 6 | 1.9055 | 0.000261727 | 0.109288
1589011 | Level 6 | 0.615816 | 0.000261727 | 0.0353193
1589013 | Level 6 | 0.998002 | 0.000261727 | 0.0572391
1589014 | Level 6 | 0.448 | 0.000261727 | 0.0256945
1589018 | Level 6 | 0.65457 | 0.000261727 | 0.037542
1589019 | Level 6 | 1.51704 | 0.000261727 | 0.0870079
1589021 | Level 6 | 0.42997 | 0.000261717 | 0.0246603
1589024 | Level 6 | 1.048 | 0.000261727 | 0.0601068
1589026 | Level 6 | 0.1526 | 0.000261727 | 0.00875217
1589031 | Level 6 | 0.7055 | 0.000261727 | 0.040463
1589036 | Level 6 | 0.0408 | 0.000261727 | 0.00234003
1589038 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1589040 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1589041 | Level 6 | 1.06611 | 0.000261727 | 0.0611452
1589042 | Level 6 | 0.0142587 | 0.000261727 | 0.000817789
1589046 | Level 6 | 0.804569 | 0.000261727 | 0.046145
1589047 | Level 6 | 0.765057 | 0.000261727 | 0.0438789
1589054 | Level 6 | 0.625042 | 0.000261727 | 0.0358485
1589056 | Level 6 | 2.71657 | 0.000261727 | 0.155805
1589057 | Level 6 | 1.40806 | 0.000261727 | 0.0807573
1589059 | Level 6 | 0.415378 | 0.000261727 | 0.0238235
1589072 | Level 6 | 1.10235 | 0.000261727 | 0.0632241
1589075 | Level 6 | 0.431217 | 0.000261727 | 0.0247319
1589076 | Level 6 | 0.257522 | 0.000261727 | 0.0147699
1589089 | Level 6 | 0.4481 | 0.000261727 | 0.0257002
1589094 | Level 6 | 0.3555 | 0.000261727 | 0.0203892
1589095 | Level 6 | 0.32955 | 0.000261727 | 0.0189009
1589097 | Level 6 | 3.52436 | 0.000261727 | 0.202135
1589098 | Level 6 | 0.215057 | 0.000261727 | 0.0123343
1589108 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1589111 | Level 6 | 1.90457 | 0.000261727 | 0.109234
1589112 | Level 6 | 1.8555 | 0.000261727 | 0.10642
1589113 | Level 6 | 0.952029 | 0.000261727 | 0.0546024
1589115 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1589116 | Level 6 | 0.171257 | 0.000261727 | 0.00982222
1589145 | Level 6 | 0.657257 | 0.000261727 | 0.0376961
1589165 | Level 6 | 0.178307 | 0.000261727 | 0.0102266
1589194 | Level 6 | 0.202187 | 0.000261727 | 0.0115962
1589199 | Level 6 | 0.00733381 | 0.000261727 | 0.000420621
1589200 | Level 6 | 0.05 | 0.000261727 | 0.00286769
1589203 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1589206 | Level 6 | 0.103041 | 0.000261727 | 0.00590979
1589215 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1589216 | Level 6 | 0.0234188 | 0.000261727 | 0.00134315
1589219 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1589236 | Level 6 | 1.75852 | 0.000261727 | 0.100858
1589247 | Level 6 | 0.2855 | 0.000261727 | 0.0163745
1589249 | Level 6 | 0.645459 | 0.000261727 | 0.0370195
1589255 | Level 6 | 1.11439 | 0.000445281 | 0.0833666
1589256 | Level 6 | 0.0068056 | 0.000445281 | 0.000509121
1589259 | Level 6 | 1.23982 | 0.000445265 | 0.0927499
1589260 | Level 6 | 6.57935 | 0.000445281 | 0.492196
1589261 | Level 6 | 0.21185 | 0.000445281 | 0.0158483
1589262 | Level 6 | 0.21185 | 0.000445281 | 0.0158483
1589263 | Level 6 | 0.0678648 | 0.000445281 | 0.00507691
1589265 | Level 6 | 2.6358 | 0.000261727 | 0.151173
1589268 | Level 6 | 2.46321 | 0.000261727 | 0.141274
1589269 | Level 6 | 0.424815 | 0.000261717 | 0.0243647
1589274 | Level 6 | 0.00269577 | 0.000445281 | 0.000201668
1589275 | Level 6 | 0.0179324 | 0.000445281 | 0.00134151
1589278 | Level 6 | 0.00269577 | 0.000445281 | 0.000201668
1589281 | Level 6 | 2.23222 | 0.000445281 | 0.16699
1589290 | Level 6 | 0.00450435 | 0.000261727 | 0.000258341
1589291 | Level 6 | 0.199999 | 0.000261727 | 0.0114707
1589294 | Level 6 | 0.00450487 | 0.000261727 | 0.000258371
1589297 | Level 6 | 0.0177293 | 0.000261727 | 0.00101684
1589300 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1589301 | Level 6 | 0.0179324 | 0.000261727 | 0.00102849
1589304 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1589307 | Level 6 | 0.291829 | 0.000261717 | 0.0167375
1589317 | Level 6 | 0.241107 | 0.000261727 | 0.0138284
1589318 | Level 6 | 1.35839 | 0.000261727 | 0.0779089
1589326 | Level 6 | 1.11439 | 0.000445281 | 0.0833666
1589327 | Level 6 | 0.0068056 | 0.000445281 | 0.000509121
1589330 | Level 6 | 1.23982 | 0.000445281 | 0.0927499
1589331 | Level 6 | 6.57935 | 0.000445281 | 0.492196
1589332 | Level 6 | 0.20485 | 0.000445281 | 0.0153247
1589333 | Level 6 | 0.21185 | 0.000445281 | 0.0158483
1589334 | Level 6 | 0.12059 | 0.000445281 | 0.00902121
1589339 | Level 6 | 2.40387 | 0.000261727 | 0.137871
1589340 | Level 6 | 0.424815 | 0.000261717 | 0.0243647
1589343 | Level 6 | 0.00269577 | 0.000445281 | 0.000201668
1589344 | Level 6 | 0.0179324 | 0.000445281 | 0.00134151
1589347 | Level 6 | 0.00269577 | 0.000445281 | 0.000201668
1589350 | Level 6 | 2.23222 | 0.000445281 | 0.16699
1589359 | Level 6 | 0.0144049 | 0.000261727 | 0.000826173
1589360 | Level 6 | 0.2 | 0.000261727 | 0.0114707
1589363 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1589366 | Level 6 | 0.017729 | 0.000261727 | 0.00101682
1589369 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1589370 | Level 6 | 0.0179324 | 0.000261727 | 0.00102849
1589373 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1589376 | Level 6 | 0.291829 | 0.000261717 | 0.0167375
1589385 | Level 6 | 0.241107 | 0.000261727 | 0.0138284
1589386 | Level 6 | 1.35867 | 0.000261727 | 0.0779247
1589390 | Level 6 | 1.548 | 0.000261727 | 0.0887836
1589433 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1589438 | Level 6 | 2.52133 | 0.000261727 | 0.144607
1589440 | Level 6 | 1.8555 | 0.000261727 | 0.10642
1589441 | Level 6 | 0.615816 | 0.000261727 | 0.0353193
1589443 | Level 6 | 0.998002 | 0.000261727 | 0.0572391
1589444 | Level 6 | 0.448 | 0.000261727 | 0.0256945
1589448 | Level 6 | 0.639628 | 0.000261727 | 0.036685
1589449 | Level 6 | 1.51704 | 0.000261727 | 0.0870079
1589451 | Level 6 | 0.441527 | 0.000261717 | 0.0253232
1589454 | Level 6 | 0.998002 | 0.000261727 | 0.0572391
1589456 | Level 6 | 0.102603 | 0.000261727 | 0.00588469
1589461 | Level 6 | 0.755501 | 0.000261727 | 0.0433308
1589464 | Level 6 | 0.0408183 | 0.000261727 | 0.00234108
1589465 | Level 6 | 0.2426 | 0.000261727 | 0.013914
1589466 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1589468 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1589469 | Level 6 | 1.06711 | 0.000261727 | 0.0612025
1589470 | Level 6 | 0.0142591 | 0.000261727 | 0.000817811
1589482 | Level 6 | 0.662603 | 0.000261727 | 0.0380028
1589484 | Level 6 | 2.74157 | 0.000261717 | 0.157239
1589485 | Level 6 | 1.3965 | 0.000261727 | 0.0800944
1589487 | Level 6 | 0.42382 | 0.000261727 | 0.0243076
1589500 | Level 6 | 1.10236 | 0.000261727 | 0.0632245
1589503 | Level 6 | 0.431863 | 0.000261717 | 0.024769
1589504 | Level 6 | 0.257457 | 0.000261727 | 0.0147661
1589519 | Level 6 | 0.241107 | 0.000261727 | 0.0138284
1589521 | Level 6 | 3.52891 | 0.000261727 | 0.202396
1589522 | Level 6 | 0.215057 | 0.000261727 | 0.0123343
1589532 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1589535 | Level 6 | 1.90457 | 0.000261727 | 0.109234
1589536 | Level 6 | 1.8555 | 0.000261727 | 0.10642
1589538 | Level 6 | 0.0174387 | 0.000261727 | 0.00100017
1589539 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1589540 | Level 6 | 0.171257 | 0.000261727 | 0.00982222
1589559 | Level 6 | 0.652707 | 0.000261727 | 0.0374352
1589577 | Level 6 | 0.178307 | 0.000261727 | 0.0102266
1589598 | Level 6 | 0.202207 | 0.000261717 | 0.0115973
1589599 | Level 6 | 0.00733381 | 0.000261727 | 0.000420621
1589600 | Level 6 | 0.0775 | 0.000261727 | 0.00444491
1589603 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1589606 | Level 6 | 0.0359429 | 0.000261727 | 0.00206146
1589615 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1589616 | Level 6 | 0.0234188 | 0.000261727 | 0.00134315
1589619 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1589636 | Level 6 | 1.75852 | 0.000261727 | 0.100858
1589650 | Level 6 | 1.548 | 0.000261727 | 0.0887836
1589656 | Level 6 | 0.645457 | 0.000261727 | 0.0370193
1589663 | Level 6 | 0.221497 | 0.000261727 | 0.0127037
1589777 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1589782 | Level 6 | 2.52533 | 0.000261727 | 0.144837
1589784 | Level 6 | 1.8555 | 0.000261727 | 0.10642
1589785 | Level 6 | 0.615816 | 0.000261727 | 0.0353193
1589787 | Level 6 | 0.998002 | 0.000261727 | 0.0572391
1589788 | Level 6 | 0.448 | 0.000261727 | 0.0256945
1589792 | Level 6 | 0.639621 | 0.000261727 | 0.0366847
1589793 | Level 6 | 1.51705 | 0.000261727 | 0.0870082
1589795 | Level 6 | 0.441527 | 0.000261727 | 0.0253232
1589798 | Level 6 | 0.998002 | 0.000261727 | 0.0572391
1589800 | Level 6 | 0.102604 | 0.000261727 | 0.00588469
1589805 | Level 6 | 0.755502 | 0.000261727 | 0.0433308
1589808 | Level 6 | 0.040818 | 0.000261727 | 0.00234106
1589810 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1589813 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1589814 | Level 6 | 1.06711 | 0.000261727 | 0.0612025
1589815 | Level 6 | 0.0143382 | 0.000261727 | 0.000822347
1589829 | Level 6 | 2.69157 | 0.000261727 | 0.154371
1589831 | Level 6 | 1.40806 | 0.000261727 | 0.0807573
1589833 | Level 6 | 0.432222 | 0.000261727 | 0.0247895
1589846 | Level 6 | 1.10236 | 0.000261727 | 0.0632242
1589849 | Level 6 | 0.416813 | 0.000261727 | 0.0239058
1589850 | Level 6 | 0.257463 | 0.000261727 | 0.0147665
1589851 | Level 6 | 0.105471 | 0.000261727 | 0.00604917
1589860 | Level 6 | 1.548 | 0.000261727 | 0.0887836
1589862 | Level 6 | 0.4481 | 0.000261727 | 0.0257002
1589866 | Level 6 | 0.241107 | 0.000261727 | 0.0138284
1589868 | Level 6 | 3.52436 | 0.000261727 | 0.202135
1589869 | Level 6 | 0.215057 | 0.000261727 | 0.0123343
1589879 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1589882 | Level 6 | 1.90457 | 0.000261727 | 0.109234
1589883 | Level 6 | 1.8555 | 0.000261727 | 0.10642
1589884 | Level 6 | 1.07862 | 0.000261727 | 0.0618628
1589885 | Level 6 | 0.0174378 | 0.000261727 | 0.00100012
1589886 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1589887 | Level 6 | 0.171257 | 0.000261727 | 0.00982222
1589904 | Level 6 | 0.657257 | 0.000261727 | 0.0376961
1589922 | Level 6 | 0.178307 | 0.000261727 | 0.0102266
1589943 | Level 6 | 0.202164 | 0.000261727 | 0.0115949
1589963 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1589964 | Level 6 | 0.0234188 | 0.000261727 | 0.00134315
1589967 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1589986 | Level 6 | 1.75852 | 0.000261727 | 0.100858
1590025 | Level 6 | 0.28551 | 0.000261727 | 0.0163751
1590027 | Level 6 | 0.647057 | 0.000261727 | 0.0371111
1590045 | Level 6 | 1.11439 | 0.000445281 | 0.0833665
1590046 | Level 6 | 0.00680491 | 0.000445281 | 0.00050907
1590049 | Level 6 | 1.23982 | 0.000445281 | 0.0927499
1590050 | Level 6 | 6.57935 | 0.000445281 | 0.492196
1590051 | Level 6 | 0.20485 | 0.000445281 | 0.0153247
1590052 | Level 6 | 0.21185 | 0.000445281 | 0.0158483
1590053 | Level 6 | 0.605363 | 0.000445281 | 0.0452867
1590054 | Level 6 | 3.25912 | 0.000445281 | 0.243812
1590055 | Level 6 | 3.3027 | 0.000261727 | 0.189422
1590058 | Level 6 | 1.9333 | 0.000261727 | 0.110882
1590059 | Level 6 | 0.424815 | 0.000261727 | 0.0243647
1590064 | Level 6 | 0.00269577 | 0.000445281 | 0.000201668
1590065 | Level 6 | 0.0179324 | 0.000445281 | 0.00134151
1590068 | Level 6 | 0.00269577 | 0.000445281 | 0.000201668
1590071 | Level 6 | 2.23222 | 0.000445281 | 0.16699
1590080 | Level 6 | 0.0115765 | 0.000261727 | 0.000663952
1590081 | Level 6 | 0.2 | 0.000261727 | 0.0114707
1590084 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1590087 | Level 6 | 0.017729 | 0.000261727 | 0.00101682
1590090 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1590091 | Level 6 | 0.0179324 | 0.000261727 | 0.00102849
1590094 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
1590097 | Level 6 | 0.291829 | 0.000261727 | 0.0167375
1590126 | Level 6 | 0.241091 | 0.000261727 | 0.0138274
1590127 | Level 6 | 1.35873 | 0.000261727 | 0.0779281
1590134 | Level 6 | 2.94994 | 0.000261727 | 0.16919
1590135 | Level 6 | 2.90412 | 0.000445281 | 0.217255
1591151 | Level 6 | 0.367057 | 0.000261727 | 0.0210521
1591350 | Level 6 | 1.398 | 0.000261727 | 0.0801806
1616694 | Level 6 | 1.8926 | 0.000261727 | 0.108548
1617269 | Level 6 | 1.98457 | 0.000261717 | 0.113823
1617307 | Level 6 | 0.108951 | 0.000261727 | 0.00624877
1617315 | Level 6 | 1.8926 | 0.000261727 | 0.108548
1617330 | Level 6 | 0.367057 | 0.000261727 | 0.0210521
1617331 | Level 6 | 1.24 | 0.000261727 | 0.0711186
1617339 | Level 6 | 0.217057 | 0.000261727 | 0.012449
1617340 | Level 6 | 1.32 | 0.000261727 | 0.0757069
1617348 | Level 6 | 0.367057 | 0.000261727 | 0.0210521
1617349 | Level 6 | 1.398 | 0.000261727 | 0.0801806
1651720 | Level 2 | 0.222978 | 0.00113992 | 0.0266893
1651727 | Level 2 | 0.320618 | 0.00113992 | 0.0383763
1651737 | Level 2 | 2.15475 | 0.00113992 | 0.257912
1652327 | Level 2 | 0.23171 | 0.000677323 | 0.0213786
1652328 | Level 2 | 0.543708 | 0.000677323 | 0.050165
1652331 | Level 2 | 1.95497 | 0.000677323 | 0.180375
1652644 | Level 2 | 0.231792 | 0.000677323 | 0.0213862
1652645 | Level 2 | 0.529574 | 0.000677323 | 0.048861
1652648 | Level 2 | 2.00362 | 0.000677323 | 0.184863
1652761 | Level 2 | 0.231792 | 0.000677323 | 0.0213862
1652762 | Level 2 | 0.516987 | 0.000677323 | 0.0476996
1652765 | Level 2 | 2.00437 | 0.000677323 | 0.184933
1652910 | Level 2 | 0.243202 | 0.000677323 | 0.022439
1652911 | Level 2 | 0.50573 | 0.000677323 | 0.046661
1652914 | Level 2 | 2.00343 | 0.000677323 | 0.184846
1653034 | Level 2 | 0.295642 | 0.000677323 | 0.0272773
1653035 | Level 2 | 0.305209 | 0.000677323 | 0.02816
1653038 | Level 2 | 2.35485 | 0.000677323 | 0.217269
1653076 | Level 2 | 0.0328281 | 0.000677323 | 0.00302888
1654410 | Level 2 | 0.224102 | 0.00113992 | 0.0268239
1655076 | Level 2 | 2.45557 | 0.00113992 | 0.293919
1655226 | Level 2 | 0.310207 | 0.000677323 | 0.0286211
1655227 | Level 2 | 0.220256 | 0.000677323 | 0.0203218
1655234 | Level 2 | 2.4679 | 0.000677323 | 0.2277
1655542 | Level 2 | 0.301467 | 0.000677323 | 0.0278147
1655543 | Level 2 | 0.221506 | 0.000677323 | 0.0204372
1655548 | Level 2 | 2.45594 | 0.000677323 | 0.226597
1655669 | Level 2 | 0.293218 | 0.000677323 | 0.0270537
1655670 | Level 2 | 0.221506 | 0.000677323 | 0.0204372
1655675 | Level 2 | 2.44416 | 0.000677323 | 0.225509
1655850 | Level 2 | 0.261372 | 0.000677298 | 0.0241154
1655851 | Level 2 | 0.245411 | 0.000677323 | 0.0226427
1655856 | Level 2 | 2.41015 | 0.000677323 | 0.222371
1656061 | Level 2 | 0.347937 | 0.000677323 | 0.0321023
1656062 | Level 2 | 0.274326 | 0.000677323 | 0.0253106
1656067 | Level 2 | 2.29764 | 0.000677323 | 0.211991
1662277 | Level 2 | 0.0713206 | 0.00113992 | 0.0085367
1662285 | Level 2 | 0.0516891 | 0.000677323 | 0.00476908
1662293 | Level 2 | 0.0516891 | 0.000677323 | 0.00476908
1662301 | Level 2 | 0.0560641 | 0.000677323 | 0.00517274
1662309 | Level 2 | 0.0788844 | 0.000677323 | 0.00727825
1663489 | Level 2 | 7.65717 | 0.000677323 | 0.706486
1663514 | Level 2 | 9.96717 | 0.000677323 | 0.919617
1663516 | Level 2 | 12.2223 | 0.00113992 | 1.46295
1664875 | Level 2 | 2.96027 | 0.000677323 | 0.273128
1664876 | Level 2 | 5.31717 | 0.000677323 | 0.490586
1664877 | Level 2 | 7.62717 | 0.000677323 | 0.703718
1664878 | Level 2 | 10.0398 | 0.000677323 | 0.926315
1664879 | Level 2 | 12.3454 | 0.00113992 | 1.47767
1665697 | Level 2 | 3.06717 | 0.000677323 | 0.282991
1665698 | Level 2 | 5.37717 | 0.000677323 | 0.496122
1665699 | Level 2 | 9.25575 | 0.000677323 | 0.853979
1665700 | Level 2 | 11.6072 | 0.000677323 | 1.07093
1665703 | Level 2 | 5.37717 | 0.000677323 | 0.496122
1665704 | Level 2 | 7.68717 | 0.000677323 | 0.709254
1665705 | Level 2 | 9.9499 | 0.000677323 | 0.918024
1665706 | Level 2 | 12.3028 | 0.00113992 | 1.47257
1665730 | Level 2 | 0.0516891 | 0.000677323 | 0.00476908
1665738 | Level 2 | 0.0133058 | 0.000677323 | 0.00122766
1666232 | Level 2 | 1.38171 | 0.000677323 | 0.127483
1666460 | Level 2 | 0.4298 | 0.00113992 | 0.0514448
1666494 | Level 2 | 0.4298 | 0.00113992 | 0.0514448
1666552 | Level 2 | 0.5148 | 0.000677323 | 0.0474978
1666553 | Level 2 | 0.5148 | 0.000677323 | 0.0474978
1666605 | Level 2 | 0.5948 | 0.000677323 | 0.054879
1666606 | Level 2 | 0.5948 | 0.000677323 | 0.054879
1666608 | Level 2 | 0.6748 | 0.000677323 | 0.0622602
1666609 | Level 2 | 0.6748 | 0.000677323 | 0.0622602
1666627 | Level 2 | 0.7598 | 0.000677323 | 0.0701027
1666628 | Level 2 | 0.7598 | 0.000677323 | 0.0701027
1666690 | Level 2 | 0.5974 | 0.00113992 | 0.0715056
1666691 | Level 2 | 0.6374 | 0.000677323 | 0.0588095
1666692 | Level 2 | 0.6774 | 0.000677323 | 0.0625001
1666693 | Level 2 | 0.7174 | 0.000677323 | 0.0661907
1666694 | Level 2 | 0.7574 | 0.000677323 | 0.0698812
1666695 | Level 2 | 0.5974 | 0.00113992 | 0.0715056
1666696 | Level 2 | 0.6374 | 0.000677323 | 0.0588095
1666697 | Level 2 | 0.6774 | 0.000677323 | 0.0625001
1666698 | Level 2 | 0.7174 | 0.000677323 | 0.0661907
1666699 | Level 2 | 0.7574 | 0.000677323 | 0.0698812
1666789 | Level 2 | 0.5974 | 0.000677323 | 0.0551189
1667423 | Level 2 | 1.38588 | 0.000677323 | 0.127868
1667424 | Level 2 | 1.0548 | 0.00113992 | 0.126254
1667425 | Level 2 | 1.0548 | 0.00113992 | 0.126254
1667426 | Level 2 | 1.1398 | 0.000677323 | 0.105163
1667427 | Level 2 | 1.1398 | 0.000677323 | 0.105163
1667428 | Level 2 | 1.2198 | 0.000677323 | 0.112544
1667429 | Level 2 | 1.2198 | 0.000677323 | 0.112544
1667430 | Level 2 | 1.2998 | 0.000677323 | 0.119926
1667431 | Level 2 | 1.2998 | 0.000677323 | 0.119926
1667432 | Level 2 | 1.3848 | 0.000677323 | 0.127768
1667433 | Level 2 | 1.3848 | 0.000677323 | 0.127768
1667434 | Level 2 | 0.6574 | 0.00113992 | 0.0786873
1667435 | Level 2 | 0.6974 | 0.000677323 | 0.0643454
1667436 | Level 2 | 0.7374 | 0.000677323 | 0.068036
1667437 | Level 2 | 0.7774 | 0.000677323 | 0.0717265
1667438 | Level 2 | 0.8174 | 0.000677323 | 0.0754171
1667439 | Level 2 | 0.6574 | 0.00113992 | 0.0786873
1667440 | Level 2 | 0.6974 | 0.000677323 | 0.0643454
1667441 | Level 2 | 0.7374 | 0.000677323 | 0.068036
1667442 | Level 2 | 0.7774 | 0.000677323 | 0.0717265
1667443 | Level 2 | 0.8174 | 0.000677323 | 0.0754171
1667444 | Level 2 | 0.641575 | 0.000677323 | 0.0591947
1667521 | Level 2 | 0.731407 | 0.000677323 | 0.067483
1667593 | Level 2 | 0.701575 | 0.000677323 | 0.0647306
1668046 | Level 2 | 0.880237 | 0.000677323 | 0.0812147
1668242 | Level 2 | 0.719765 | 0.000677323 | 0.0664089
1670893 | Level 2 | 1.42 | 0.00242431 | 0.247868
1670894 | Level 2 | 1.42 | 0.00242431 | 0.247868
1676799 | Level 2 | 0.837702 | 0.00155156 | 0.11698
1676866 | Level 2 | 0.886348 | 0.00242431 | 0.154716
1676875 | Level 2 | 0.953848 | 0.00242431 | 0.166499
1685700 | Level 2 | 5.80539 | 0.00620623 | 1.62137
1685843 | Level 2 | 5.3195 | 0.00620623 | 1.48567
1686199 | Level 2 | 7.33156 | 0.00620623 | 2.04761
1686232 | Level 2 | 2.25695 | 0.00620623 | 0.630338
1686331 | Level 2 | 0.063557 | 0.00620623 | 0.0177507
1686687 | Level 2 | 0.580529 | 0.00620623 | 0.162135
1687594 | Level 2 | 2.24606 | 0.00620623 | 0.627297
1687595 | Level 2 | 0.065057 | 0.00620623 | 0.0181696
1687596 | Level 2 | 0.422499 | 0.00620623 | 0.117999
1687601 | Level 2 | 0.478029 | 0.00620623 | 0.133508
1687602 | Level 2 | 0.555975 | 0.00620623 | 0.155277
1696837 | Level 2 | 2.1282 | 0.000677323 | 0.196358
1699773 | Level 2 | 1.12188 | 0.000677323 | 0.10351
1700083 | Level 2 | 0.741575 | 0.000677323 | 0.0684212
1713883 | Level 6 | 0.261259 | 0.000261727 | 0.0149842
1717806 | Level 6 | 0.947858 | 0.000261727 | 0.0543631
1723162 | Nivel 1 | 0.0387593 | 0.000261727 | 0.00222299
1723163 | Nivel 1 | 0.947858 | 0.000261727 | 0.0543631
1741097 | Level 6 | 0.261259 | 0.000261727 | 0.0149841
1741098 | Level 6 | 0.947857 | 0.000261727 | 0.0543631
1744491 | Level 6 | 0.261259 | 0.000261727 | 0.0149841
1744492 | Level 6 | 0.947857 | 0.000261727 | 0.0543631
1744496 | Level 6 | 0.261259 | 0.000261727 | 0.0149842
1744497 | Level 6 | 0.947858 | 0.000261727 | 0.0543631
1750171 | Level 6 | 0.820503 | 0.000261727 | 0.0470589
1752426 | Level 6 | 0.820503 | 0.000261727 | 0.0470589
1753547 | Level 6 | 0.820503 | 0.000261727 | 0.0470589
1753549 | Level 6 | 0.820503 | 0.000261727 | 0.0470589
1760827 | Nivel 1 | 0.0509781 | 0.000261727 | 0.00292378
1760854 | Nivel 1 | 0.0996307 | 0.000261727 | 0.00571419
1760864 | Nivel 1 | 0.33634 | 0.000261727 | 0.0192903
1760871 | Nivel 1 | 0.0996307 | 0.000261727 | 0.00571419
1761170 | Nivel 1 | 0.444809 | 0.000261727 | 0.0255115
1763141 | Nivel 1 | 0.0387586 | 0.000261727 | 0.00222295
1763142 | Nivel 1 | 0.947857 | 0.000261727 | 0.0543631
1763146 | Nivel 1 | 0.0509781 | 0.000261727 | 0.00292378
1763147 | Nivel 1 | 0.0996307 | 0.000261727 | 0.00571419
1763150 | Nivel 1 | 0.33634 | 0.000261727 | 0.0192903
1763153 | Nivel 1 | 0.0996307 | 0.000261727 | 0.00571419
1763158 | Nivel 1 | 0.444809 | 0.000261727 | 0.0255115
1767916 | Nivel 1 | 0.0387586 | 0.000261727 | 0.00222295
1767917 | Nivel 1 | 0.947857 | 0.000261727 | 0.0543631
1767921 | Nivel 1 | 0.0509781 | 0.000261727 | 0.00292378
1767922 | Nivel 1 | 0.0996307 | 0.000261727 | 0.00571419
1767925 | Nivel 1 | 0.33634 | 0.000261727 | 0.0192903
1767928 | Nivel 1 | 0.0996307 | 0.000261727 | 0.00571419
1767933 | Nivel 1 | 0.444809 | 0.000261727 | 0.0255115
1767935 | Nivel 1 | 0.0387593 | 0.000261727 | 0.00222299
1767936 | Nivel 1 | 0.947858 | 0.000261727 | 0.0543631
1767940 | Nivel 1 | 0.0509781 | 0.000261727 | 0.00292378
1767941 | Nivel 1 | 0.0996307 | 0.000261727 | 0.00571419
1767944 | Nivel 1 | 0.33634 | 0.000261727 | 0.0192903
1767947 | Nivel 1 | 0.0996307 | 0.000261727 | 0.00571419
1767952 | Nivel 1 | 0.444809 | 0.000261727 | 0.0255115
1774126 | Level 2 | 0.0387586 | 0.000261727 | 0.00222295
1774127 | Level 2 | 0.947857 | 0.000261727 | 0.0543631
1774131 | Level 2 | 0.0509781 | 0.000261727 | 0.00292378
1774132 | Level 2 | 0.0996307 | 0.000261727 | 0.00571419
1774135 | Level 2 | 0.33634 | 0.000261727 | 0.0192903
1774138 | Level 2 | 0.0996307 | 0.000261727 | 0.00571419
1774143 | Level 2 | 0.444809 | 0.000261727 | 0.0255115
1775864 | Level 2 | 0.0387586 | 0.000261727 | 0.00222295
1775865 | Level 2 | 0.947857 | 0.000261727 | 0.0543631
1775869 | Level 2 | 0.0509781 | 0.000261727 | 0.00292378
1775870 | Level 2 | 0.0996307 | 0.000261727 | 0.00571419
1775873 | Level 2 | 0.33634 | 0.000261727 | 0.0192903
1775876 | Level 2 | 0.0996307 | 0.000261727 | 0.00571419
1775881 | Level 2 | 0.444809 | 0.000261727 | 0.0255115
1777791 | Level 2 | 0.0387593 | 0.000261727 | 0.00222299
1777792 | Level 2 | 0.947858 | 0.000261727 | 0.0543631
1777796 | Level 2 | 0.0509781 | 0.000261727 | 0.00292378
1777797 | Level 2 | 0.0996307 | 0.000261727 | 0.00571419
1777800 | Level 2 | 0.33634 | 0.000261727 | 0.0192903
1777803 | Level 2 | 0.0996307 | 0.000261727 | 0.00571419
1777808 | Level 2 | 0.444809 | 0.000261727 | 0.0255115
1781198 | Level 2 | 0.0387586 | 0.000261727 | 0.00222295
1781199 | Level 2 | 0.947857 | 0.000261727 | 0.0543631
1781203 | Level 2 | 0.0509781 | 0.000261727 | 0.00292378
1781204 | Level 2 | 0.0996307 | 0.000261727 | 0.00571419
1781207 | Level 2 | 0.33634 | 0.000261727 | 0.0192903
1781210 | Level 2 | 0.0996307 | 0.000261727 | 0.00571419
1781215 | Level 2 | 0.444809 | 0.000261727 | 0.0255115
1802119 | Level 2 | 1.07702 | 0.000261727 | 0.061771
1802150 | Level 2 | 0.017438 | 0.000261727 | 0.00100013
1802159 | Level 2 | 0.429118 | 0.000261727 | 0.0246115
1810685 | Level 2 | 1.07702 | 0.000261727 | 0.061771
1810723 | Level 2 | 0.019938 | 0.000261727 | 0.00114352
1810732 | Level 2 | 0.42912 | 0.000261727 | 0.0246116
1836911 | Nivel 1 | 0.464617 | 0.000261727 | 0.0266475
1839026 | Nivel 1 | 0.502215 | 0.000261727 | 0.0288039
1841104 | Nivel 1 | 0.492204 | 0.000261727 | 0.0282297
1842915 | Nivel 1 | 0.502201 | 0.000261727 | 0.0288031
1850530 | Level 6 | 0.454471 | 0.000261727 | 0.0260656
1852915 | Level 6 | 0.502215 | 0.000261717 | 0.0288039
1854460 | Level 6 | 0.45469 | 0.000261727 | 0.0260781
1857382 | Level 6 | 0.502201 | 0.000261727 | 0.0288031
1983569 | Level 2 | 0.241802 | 0.000261727 | 0.0138682
1983570 | Level 2 | 0.509692 | 0.000261727 | 0.0292327
1985210 | Level 2 | 0.788601 | 0.000261727 | 0.0452292
1985211 | Level 2 | 0.8226 | 0.000261727 | 0.0471792
1985212 | Level 2 | 0.997057 | 0.000261727 | 0.0571849
1985213 | Level 2 | 0.7926 | 0.000261727 | 0.0454585
1987704 | Level 2 | 0.233416 | 0.000445281 | 0.0174616
1987705 | Level 2 | 0.240416 | 0.000445281 | 0.0179853
2006052 | Nivel 1 | 0.0118369 | 0.000261727 | 0.000678892
2006054 | Nivel 1 | 2.04169 | 0.000261727 | 0.117099
2006065 | Nivel 1 | 0.0119369 | 0.000261727 | 0.000684623
2006073 | Nivel 1 | 0.706826 | 0.000261727 | 0.0405391
2006077 | Nivel 1 | 0.743669 | 0.000261727 | 0.0426522
2006079 | Nivel 1 | 0.0119369 | 0.000261727 | 0.000684623
2006087 | Nivel 1 | 0.767057 | 0.000261727 | 0.0439936
2006093 | Nivel 1 | 0.00783803 | 0.000261727 | 0.00044954
2006095 | Nivel 1 | 0.250638 | 0.000261727 | 0.014375
2006103 | Nivel 1 | 0.0130309 | 0.000261727 | 0.000747368
2006109 | Nivel 1 | 0.0111381 | 0.000261727 | 0.000638809
2006111 | Nivel 1 | 0.631374 | 0.000261727 | 0.0362116
2006168 | Nivel 1 | 0.0303379 | 0.000261727 | 0.00173999
2006177 | Nivel 1 | 0.636683 | 0.000261727 | 0.0365161
2006701 | Nivel 1 | 0.030338 | 0.000261727 | 0.00174
2007070 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
2007071 | Nivel 1 | 0.125 | 0.000261727 | 0.00716921
2007074 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
2007077 | Nivel 1 | 0.0399794 | 0.000261727 | 0.00229297
2008630 | Nivel 1 | 0.952057 | 0.000261727 | 0.054604
2010300 | Nivel 1 | 1.59457 | 0.000261727 | 0.0914544
2012029 | Nivel 1 | 0.188638 | 0.000261727 | 0.0108191
2012038 | Nivel 1 | 0.360934 | 0.000261727 | 0.0207009
2015765 | Level 2 | 0.4481 | 0.000261727 | 0.0257002
2016081 | Level 2 | 0.0072 | 0.000261727 | 0.000412947
2016473 | Level 2 | 0.00720015 | 0.000261727 | 0.000412955
2016665 | Level 2 | 0.00720007 | 0.000261727 | 0.000412951
2016672 | Level 2 | 2.01775 | 0.000261727 | 0.115726
2016693 | Level 2 | 0.0026 | 0.000261727 | 0.00014912
2017132 | Level 2 | 0.7926 | 0.000261727 | 0.0454585
2017201 | Level 2 | 0.0122 | 0.000261727 | 0.000699715
2017648 | Level 2 | 0.0122 | 0.000261727 | 0.000699715
2017853 | Level 2 | 0.6979 | 0.000261727 | 0.0400271
2018193 | Level 2 | 0.272784 | 0.000261727 | 0.0156452
2018318 | Level 2 | 0.719731 | 0.000261727 | 0.0412793
2018432 | Level 2 | 0.0122 | 0.000261727 | 0.000699715
2018698 | Level 2 | 0.0047 | 0.000261727 | 0.000269562
2019635 | Level 2 | 0.0072058 | 0.000261727 | 0.000413279
2020395 | Level 2 | 0.0147 | 0.000261727 | 0.000843099
2021025 | Level 2 | 0.0072 | 0.000261717 | 0.000412947
2021034 | Level 2 | 1.22363 | 0.000261727 | 0.0701796
2021049 | Level 2 | 0.00725 | 0.000261727 | 0.000415814
2021472 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2021473 | Level 2 | 0.0734188 | 0.000261727 | 0.00421084
2021476 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2021523 | Level 2 | 0.0434256 | 0.000261727 | 0.00249062
2022446 | Level 2 | 0.0072 | 0.000261727 | 0.000412947
2022455 | Level 2 | 2.01775 | 0.000261727 | 0.115725
2022464 | Level 2 | 0.0118002 | 0.000261727 | 0.000676786
2022735 | Level 2 | 0.792601 | 0.000261727 | 0.0454586
2022771 | Level 2 | 0.697901 | 0.000261727 | 0.0400272
2022891 | Level 2 | 0.0072 | 0.000261727 | 0.000412947
2022898 | Level 2 | 0.719731 | 0.000261727 | 0.0412793
2022907 | Level 2 | 0.0072 | 0.000261727 | 0.000412947
2023207 | Level 2 | 0.0072 | 0.000261727 | 0.000412947
2023216 | Level 2 | 0.272784 | 0.000261727 | 0.0156452
2023328 | Level 2 | 0.0308801 | 0.000261727 | 0.00177109
2023337 | Level 2 | 0.261665 | 0.000261727 | 0.0150075
2024282 | Level 2 | 0.102611 | 0.000261727 | 0.00588513
2024579 | Level 2 | 0.048 | 0.000261727 | 0.00275298
2026126 | Level 2 | 0.0146297 | 0.000261727 | 0.00083907
2026568 | Level 2 | 0.0972 | 0.000261727 | 0.00557478
2026578 | Level 2 | 1.36787 | 0.000261727 | 0.0784526
2027202 | Level 2 | 1.0932 | 0.000261727 | 0.062699
2027366 | Level 2 | 0.00770052 | 0.000261727 | 0.000441653
2040174 | Nivel 1 | 0.909107 | 0.000261727 | 0.0521407
2040176 | Nivel 1 | 0.27545 | 0.000261727 | 0.0157981
