Properties of the parts of a building model (IFC4), part 4 of 18

# IfcCableCarrierSegment: Conduit with Fittings:PVC (4616)
Name (Conduit with Fittings:PVC:...) | In | Length (m) | CrossSectionArea (m2) | OuterSurfaceArea (m2)
2040185 | Nivel 1 | 0.809067 | 0.000261727 | 0.046403
2040905 | Level 2 | 1.06665 | 0.000261727 | 0.0611763
2040956 | Level 2 | 0.1497 | 0.000261727 | 0.00858585
2040965 | Level 2 | 0.0277618 | 0.000261727 | 0.00159224
2065245 | Level 2 | 0.0072 | 0.000261727 | 0.000412947
2065256 | Level 2 | 2.01775 | 0.000261727 | 0.115725
2065273 | Level 2 | 0.0118002 | 0.000261717 | 0.000676783
2067935 | Level 2 | 0.7926 | 0.000261727 | 0.0454585
2068007 | Level 2 | 0.0072 | 0.000261727 | 0.000412947
2068014 | Level 2 | 0.719731 | 0.000261727 | 0.0412793
2068029 | Level 2 | 0.0072 | 0.000261727 | 0.000412947
2069823 | Level 2 | 0.0072 | 0.000261727 | 0.000412947
2069832 | Level 2 | 0.272784 | 0.000261727 | 0.0156452
2071085 | Level 2 | 0.0072 | 0.000261727 | 0.000412947
2071096 | Level 2 | 0.249082 | 0.000261727 | 0.0142858
2074505 | Nivel 1 | 0.0228375 | 0.000261717 | 0.00130982
2074512 | Nivel 1 | 2.04172 | 0.000261727 | 0.1171
2074527 | Nivel 1 | 0.0129394 | 0.000261727 | 0.000742123
2074529 | Nivel 1 | 0.743602 | 0.000261727 | 0.0426483
2074547 | Nivel 1 | 0.0129353 | 0.000261717 | 0.000741885
2074549 | Nivel 2 | 0.296722 | 0.000261727 | 0.0170181
2074563 | Nivel 1 | 0.767057 | 0.000261727 | 0.0439936
2074571 | Nivel 1 | 0.0128395 | 0.000261727 | 0.000736393
2074584 | Nivel 1 | 0.048 | 0.000261727 | 0.00275298
2074593 | Nivel 1 | 0.755503 | 0.000261727 | 0.0433309
2074595 | Nivel 1 | 0.80457 | 0.000261727 | 0.0461451
2074602 | Nivel 1 | 0.253138 | 0.000261727 | 0.0145184
2074622 | Nivel 1 | 0.0130309 | 0.000261727 | 0.000747368
2075166 | Level 2 | 0.00345 | 0.000261727 | 0.00019787
2075176 | Level 2 | 0.917614 | 0.000261727 | 0.0526285
2075191 | Level 2 | 0.0797571 | 0.000261727 | 0.00457436
2082917 | Nivel 1 | 0.0261415 | 0.000261727 | 0.00149931
2082927 | Nivel 1 | 0.631373 | 0.000261727 | 0.0362116
2085022 | Nivel 1 | 0.254571 | 0.000261727 | 0.0146006
2085023 | Nivel 1 | 0.21706 | 0.000261727 | 0.0124492
2085025 | Nivel 1 | 0.0303402 | 0.000261727 | 0.00174012
2085030 | Nivel 1 | 0.636683 | 0.000261727 | 0.0365161
2085031 | Nivel 1 | 0.0303369 | 0.000261727 | 0.00173993
2085034 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
2085035 | Nivel 1 | 0.125 | 0.000261727 | 0.00716921
2085038 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
2085041 | Nivel 1 | 0.0399794 | 0.000261727 | 0.00229297
2087816 | Nivel 1 | 0.00788792 | 0.000261727 | 0.000452401
2087823 | Nivel 1 | 0.193138 | 0.000261727 | 0.0110772
2093683 | Nivel 1 | 3.68933 | 0.000261727 | 0.211597
2096449 | Nivel 1 | 1.06711 | 0.000261727 | 0.0612025
2096797 | Nivel 1 | 1.59457 | 0.000261727 | 0.0914544
2100495 | Nivel 1 | 1.04707 | 0.000261727 | 0.0600531
2103181 | Nivel 1 | 1.03611 | 0.000261727 | 0.0594246
2103182 | Nivel 1 | 0.27545 | 0.000261727 | 0.0157981
2103193 | Nivel 1 | 3.2319 | 0.000261727 | 0.185361
2103367 | Level 2 | 0.0072 | 0.000261727 | 0.000412947
2103371 | Level 2 | 0.468028 | 0.000261727 | 0.0268431
2103381 | Level 2 | 0.00970025 | 0.000261727 | 0.000556345
2103392 | Level 2 | 0.0202254 | 0.000261727 | 0.00116
2103394 | Level 2 | 0.0532323 | 0.000261717 | 0.00305307
2103396 | Level 2 | 0.0202254 | 0.000261717 | 0.00116
2103401 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2103402 | Level 2 | 0.0809188 | 0.000261727 | 0.00464099
2103405 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2103409 | Level 2 | 0.6691 | 0.000261717 | 0.0383753
2103423 | Level 2 | 0.0165348 | 0.000261727 | 0.000948331
2103425 | Level 2 | 0.189332 | 0.000261727 | 0.0108589
2103446 | Level 2 | 0.0218315 | 0.000261727 | 0.00125212
2103457 | Level 2 | 1.59507 | 0.000261727 | 0.0914829
2105003 | Level 2 | 0.998002 | 0.000261727 | 0.0572391
2107839 | Level 2 | 1.05665 | 0.000261727 | 0.0606028
2107840 | Level 2 | 0.3172 | 0.000261727 | 0.0181926
2107843 | Level 2 | 3.25411 | 0.000261727 | 0.186635
2108715 | Level 2 | 0.409257 | 0.000261727 | 0.0234724
2124252 | Nivel 1 | 0.0168252 | 0.000261727 | 0.000964988
2124254 | Nivel 1 | 2.04171 | 0.000261727 | 0.1171
2124275 | Nivel 1 | 0.699326 | 0.000261727 | 0.0401089
2124277 | Nivel 1 | 0.743652 | 0.000261727 | 0.0426512
2124284 | Nivel 1 | 0.0169369 | 0.000261727 | 0.000971391
2124294 | Nivel 1 | 0.804569 | 0.000261727 | 0.046145
2124296 | Nivel 1 | 0.804569 | 0.000261717 | 0.046145
2124302 | Nivel 1 | 0.767057 | 0.000261727 | 0.0439936
2124376 | Nivel 1 | 0.00783877 | 0.000261727 | 0.000449583
2125766 | Nivel 1 | 0.048 | 0.000261727 | 0.00275298
2130232 | Nivel 1 | 0.0205541 | 0.000261727 | 0.00117885
2131826 | Nivel 1 | 0.0161354 | 0.000261727 | 0.000925423
2136254 | Nivel 1 | 0.254571 | 0.000261727 | 0.0146006
2136256 | Nivel 1 | 0.0303402 | 0.000261727 | 0.00174012
2136259 | Nivel 1 | 0.636683 | 0.000261727 | 0.0365161
2136260 | Nivel 1 | 0.0301287 | 0.000261727 | 0.00172799
2136263 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
2136264 | Nivel 1 | 0.125 | 0.000261727 | 0.00716921
2136267 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
2136270 | Nivel 1 | 0.0399794 | 0.000261727 | 0.00229297
2141913 | Nivel 1 | 0.204391 | 0.000261727 | 0.0117226
2156550 | Level 2 | 0.0047 | 0.000261727 | 0.000269562
2156565 | Level 2 | 2.01775 | 0.000261727 | 0.115726
2156580 | Level 2 | 0.00930017 | 0.000261727 | 0.000533399
2156826 | Level 2 | 0.0072 | 0.000261727 | 0.000412947
2156836 | Level 2 | 0.272784 | 0.000261727 | 0.0156452
2158006 | Level 2 | 0.792601 | 0.000261727 | 0.0454586
2158320 | Level 2 | 0.0321301 | 0.000261727 | 0.00184278
2158327 | Level 2 | 0.744661 | 0.000261727 | 0.0427091
2158342 | Level 2 | 0.0321301 | 0.000261727 | 0.00184278
2158938 | Level 2 | 0.0121651 | 0.000261727 | 0.000697711
2158949 | Level 2 | 0.27713 | 0.000261727 | 0.0158944
2158956 | Level 2 | 0.20543 | 0.000261727 | 0.0117822
2160721 | Level 2 | 0.0129106 | 0.000261727 | 0.000740468
2160730 | Level 2 | 0.931431 | 0.000261727 | 0.053421
2161270 | Nivel 1 | 1.59457 | 0.000261727 | 0.0914544
2161274 | Nivel 1 | 0.196942 | 0.000261727 | 0.0112954
2161310 | Nivel 1 | 1.04111 | 0.000261727 | 0.0597113
2161311 | Nivel 1 | 0.27545 | 0.000261727 | 0.0157981
2161314 | Nivel 1 | 0.481702 | 0.000261727 | 0.0276274
2161317 | Nivel 1 | 3.7544 | 0.000261727 | 0.215329
2162043 | Level 2 | 0.0110177 | 0.000261727 | 0.000631908
2163694 | Level 2 | 0.0110176 | 0.000261727 | 0.0006319
2163704 | Level 2 | 0.663246 | 0.000261727 | 0.0380396
2163713 | Level 2 | 0.0110176 | 0.000261727 | 0.0006319
2163901 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2163902 | Level 2 | 0.08 | 0.000261727 | 0.0045883
2163905 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2164047 | Level 2 | 0.0482972 | 0.000261717 | 0.00277002
2167515 | Level 2 | 0.4481 | 0.000261727 | 0.0257002
2171280 | Level 2 | 0.0125864 | 0.000261727 | 0.000721874
2171289 | Level 2 | 0.178836 | 0.000261727 | 0.0102569
2182186 | Level 2 | 0.202184 | 0.000261727 | 0.011596
2182313 | Level 2 | 0.0143536 | 0.000261727 | 0.000823233
2197709 | Level 2 | 0.0171301 | 0.000261727 | 0.000982475
2197728 | Level 2 | 0.667688 | 0.000261727 | 0.0382944
2197744 | Level 2 | 0.0171301 | 0.000261717 | 0.000982475
2197824 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2197825 | Level 2 | 0.0859188 | 0.000261727 | 0.00492776
2197828 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2197852 | Level 2 | 0.0490485 | 0.000261727 | 0.00281311
2200095 | Level 2 | 0.00986164 | 0.000261727 | 0.000565601
2210034 | Nivel 1 | 0.0183334 | 0.000261727 | 0.00105149
2210037 | Nivel 1 | 2.04219 | 0.000261727 | 0.117127
2210058 | Nivel 1 | 0.684326 | 0.000261727 | 0.0392486
2210066 | Nivel 1 | 0.743669 | 0.000261727 | 0.0426522
2210074 | Nivel 1 | 0.0229379 | 0.000261727 | 0.00131557
2210089 | Nivel 1 | 0.021137 | 0.000261727 | 0.00121229
2210119 | Nivel 1 | 0.00803087 | 0.000261727 | 0.0004606
2210150 | Nivel 1 | 0.048 | 0.000261727 | 0.00275298
2210152 | Nivel 1 | 0.00836907 | 0.000261727 | 0.000479997
2210161 | Nivel 1 | 0.767057 | 0.000261727 | 0.0439936
2210171 | Nivel 1 | 0.254569 | 0.000261727 | 0.0146005
2210172 | Nivel 1 | 0.0303379 | 0.000261727 | 0.00173999
2210173 | Nivel 1 | 0.636683 | 0.000261727 | 0.0365161
2210174 | Nivel 1 | 0.0301411 | 0.000261727 | 0.0017287
2210175 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
2210176 | Nivel 1 | 0.125 | 0.000261727 | 0.00716921
2210179 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
2210182 | Nivel 1 | 0.0399794 | 0.000261727 | 0.00229297
2210229 | Nivel 1 | 0.188638 | 0.000261727 | 0.0108191
2210262 | Nivel 1 | 1.06711 | 0.000261727 | 0.0612025
2210271 | Nivel 1 | 1.59457 | 0.000261727 | 0.0914544
2210287 | Nivel 1 | 0.285509 | 0.000261727 | 0.016375
2210298 | Nivel 1 | 1.04706 | 0.000261727 | 0.0600526
2210323 | Nivel 1 | 1.03411 | 0.000261727 | 0.0593099
2210324 | Nivel 1 | 0.27545 | 0.000261727 | 0.0157981
2210326 | Nivel 1 | 3.2344 | 0.000261727 | 0.185505
2210353 | Nivel 1 | 0.856077 | 0.000261727 | 0.0490992
2236873 | Level 2 | 1.06665 | 0.000261727 | 0.0611763
2236874 | Level 2 | 0.3172 | 0.000261717 | 0.0181926
2236875 | Level 2 | 3.71884 | 0.000261727 | 0.213289
2236890 | Level 2 | 0.409257 | 0.000261727 | 0.0234724
2237475 | Level 2 | 1.06665 | 0.000261727 | 0.0611763
2237476 | Level 2 | 0.326536 | 0.000261727 | 0.018728
2237479 | Level 2 | 3.74441 | 0.000261727 | 0.214755
2237485 | Level 6 | 0.278619 | 0.000261727 | 0.0159798
2237486 | Level 6 | 0.254569 | 0.000261727 | 0.0146005
2237487 | Level 6 | 0.0164369 | 0.000261717 | 0.000942715
2237488 | Level 6 | 0.0118369 | 0.000261727 | 0.000678893
2237489 | Level 6 | 2.04169 | 0.000261727 | 0.117099
2237516 | Level 6 | 1.15457 | 0.000261727 | 0.0662188
2237517 | Level 6 | 0.804569 | 0.000261727 | 0.046145
2237518 | Level 6 | 0.804569 | 0.000261727 | 0.046145
2237519 | Level 6 | 0.296722 | 0.000261727 | 0.0170181
2237520 | Level 6 | 0.0119369 | 0.000261727 | 0.000684623
2237521 | Level 6 | 0.0119369 | 0.000261727 | 0.000684623
2237526 | Level 6 | 0.743669 | 0.000261727 | 0.0426522
2237527 | Level 6 | 0.0119369 | 0.000261727 | 0.000684623
2237532 | Level 6 | 0.767057 | 0.000261727 | 0.0439936
2237555 | Level 6 | 0.754569 | 0.000261727 | 0.0432773
2237556 | Level 6 | 0.188638 | 0.000261727 | 0.0108191
2237557 | Level 6 | 0.706826 | 0.000261727 | 0.0405391
2237558 | Level 6 | 0.00783803 | 0.000261727 | 0.00044954
2237559 | Level 6 | 0.250638 | 0.000261727 | 0.014375
2237593 | Level 6 | 0.048 | 0.000261727 | 0.00275298
2237637 | Level 6 | 0.2426 | 0.000261727 | 0.013914
2237638 | Level 6 | 0.0635071 | 0.000261717 | 0.00364236
2237639 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2237640 | Level 6 | 0.0234188 | 0.000261727 | 0.00134315
2237643 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2237646 | Level 6 | 0.136901 | 0.000261727 | 0.00785178
2237653 | Level 6 | 0.254569 | 0.000261727 | 0.0146005
2237654 | Level 6 | 0.0111379 | 0.000261727 | 0.000638801
2237655 | Level 6 | 0.631374 | 0.000261727 | 0.0362116
2237671 | Level 6 | 0.254569 | 0.000261727 | 0.0146005
2237672 | Level 6 | 0.254619 | 0.000261727 | 0.0146033
2237673 | Level 6 | 0.941552 | 0.000261727 | 0.0540015
2237674 | Level 6 | 0.0893379 | 0.000261727 | 0.00512386
2237675 | Level 6 | 0.0130309 | 0.000261727 | 0.000747368
2237695 | Level 6 | 0.254569 | 0.000261727 | 0.0146005
2237696 | Level 6 | 0.0303379 | 0.000261727 | 0.00173999
2237699 | Level 6 | 0.636683 | 0.000261727 | 0.0365161
2237700 | Level 6 | 0.030338 | 0.000261727 | 0.00174
2237701 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2237702 | Level 6 | 0.125 | 0.000261727 | 0.00716921
2237705 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2237708 | Level 6 | 0.0399794 | 0.000261727 | 0.00229297
2237755 | Level 6 | 1.59457 | 0.000261727 | 0.0914544
2237782 | Level 6 | 1.04706 | 0.000261727 | 0.0600526
2237825 | Level 6 | 0.010819 | 0.000261727 | 0.000620507
2237827 | Level 6 | 0.776126 | 0.000261727 | 0.0445137
2237829 | Level 6 | 0.00913791 | 0.000261727 | 0.000524093
2237834 | Level 6 | 0.187426 | 0.000261727 | 0.0107496
2237836 | Level 6 | 0.589 | 0.000261727 | 0.0337813
2237840 | Level 6 | 0.0146261 | 0.000261727 | 0.000838859
2237844 | Level 6 | 0.364346 | 0.000261727 | 0.0208966
2237857 | Level 6 | 0.804569 | 0.000261727 | 0.046145
2237872 | Level 6 | 0.0443704 | 0.000261727 | 0.0025448
2237882 | Level 6 | 1.90457 | 0.000261727 | 0.109234
2237884 | Level 6 | 0.12072 | 0.000261727 | 0.00692376
2237893 | Level 6 | 0.0174481 | 0.000261727 | 0.00100072
2237906 | Level 6 | 1.07111 | 0.000261727 | 0.061432
2237907 | Level 6 | 0.809067 | 0.000261727 | 0.046403
2237908 | Level 6 | 3.68933 | 0.000261727 | 0.211597
2237932 | Level 6 | 0.0810395 | 0.000261727 | 0.00464791
2237933 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2237934 | Level 6 | 0.125 | 0.000261727 | 0.00716921
2237946 | Level 6 | 0.278619 | 0.000261727 | 0.0159798
2237947 | Level 6 | 0.027438 | 0.000261727 | 0.00157367
2237948 | Level 6 | 0.0228375 | 0.000261717 | 0.00130982
2237949 | Level 6 | 2.04172 | 0.000261727 | 0.1171
2237967 | Level 6 | 0.254569 | 0.000261727 | 0.0146005
2237980 | Level 6 | 1.15457 | 0.000261727 | 0.0662188
2237981 | Level 6 | 0.804568 | 0.000261727 | 0.046145
2237982 | Level 6 | 0.804568 | 0.000261727 | 0.046145
2237983 | Level 6 | 0.0129364 | 0.000261717 | 0.000741948
2237984 | Level 6 | 0.0129394 | 0.000261727 | 0.000742123
2237985 | Level 6 | 0.743602 | 0.000261727 | 0.0426483
2237990 | Level 6 | 0.0129353 | 0.000261717 | 0.000741885
2237991 | Level 6 | 0.296722 | 0.000261727 | 0.0170181
2237994 | Level 6 | 0.767058 | 0.000261727 | 0.0439936
2239753 | Level 6 | 0.704324 | 0.000261727 | 0.0403956
2239754 | Level 6 | 0.193638 | 0.000261727 | 0.0111059
2239757 | Level 6 | 0.0128388 | 0.000261727 | 0.000736351
2239758 | Level 6 | 0.80457 | 0.000261727 | 0.046145
2239761 | Level 6 | 0.253138 | 0.000261727 | 0.0145184
2240554 | Level 6 | 0.048 | 0.000261727 | 0.00275298
2243628 | Level 6 | 0.254563 | 0.000261727 | 0.0146001
2243629 | Level 6 | 0.254575 | 0.000261727 | 0.0146008
2243630 | Level 6 | 0.254571 | 0.000261727 | 0.0146006
2243631 | Level 6 | 0.254569 | 0.000261727 | 0.0146005
2243632 | Level 6 | 0.941552 | 0.000261727 | 0.0540015
2243633 | Level 6 | 0.102451 | 0.000261727 | 0.00587597
2243634 | Level 6 | 0.0893402 | 0.000261727 | 0.00512399
2243637 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2243638 | Level 6 | 0.0234188 | 0.000261727 | 0.00134315
2243641 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2243644 | Level 6 | 0.14887 | 0.000261727 | 0.00853825
2243649 | Level 6 | 0.0130244 | 0.000261727 | 0.000746998
2243660 | Level 6 | 0.0261415 | 0.000261727 | 0.00149931
2243661 | Level 6 | 0.631373 | 0.000261727 | 0.0362116
2246783 | Level 2 | 2.15 | 0.00155156 | 0.300234
2246785 | Level 2 | 2.15 | 0.00242431 | 0.375293
2246787 | Level 2 | 2.15 | 0.00242431 | 0.375293
2246789 | Level 2 | 2.15 | 0.00155156 | 0.300234
2246791 | Level 2 | 2.15 | 0.00242431 | 0.375293
2246793 | Level 2 | 2.15 | 0.00242431 | 0.375293
2246795 | Level 2 | 0.7782 | 0.00155156 | 0.108671
2246797 | Level 2 | 0.772523 | 0.00242431 | 0.134848
2246799 | Level 2 | 0.772523 | 0.00242431 | 0.134848
2246801 | Level 2 | 2.15 | 0.00155156 | 0.300234
2246803 | Level 2 | 2.15 | 0.00242431 | 0.375293
2246805 | Level 2 | 2.15 | 0.00242431 | 0.375293
2246807 | Level 2 | 2.15 | 0.00155156 | 0.300234
2246809 | Level 2 | 2.15 | 0.00242431 | 0.375293
2246811 | Level 2 | 2.15 | 0.00242431 | 0.375293
2246813 | Level 2 | 2.15 | 0.00155156 | 0.300234
2246815 | Level 2 | 2.15 | 0.00242431 | 0.375293
2246817 | Level 2 | 2.15 | 0.00242431 | 0.375293
2246987 | Level 2 | 2.15 | 0.00155156 | 0.300234
2246988 | Level 2 | 2.15 | 0.00155156 | 0.300234
2246989 | Level 2 | 0.7782 | 0.00155156 | 0.108671
2246990 | Level 2 | 2.15 | 0.00155156 | 0.300234
2246991 | Level 2 | 2.15 | 0.00155156 | 0.300234
2246992 | Level 2 | 2.15 | 0.00155156 | 0.300234
2248321 | Level 2 | 0.777702 | 0.00155156 | 0.108601
2252898 | Level 2 | 4.62398 | 0.000445281 | 0.345916
2252934 | Level 2 | 4.4189 | 0.000261727 | 0.25344
2252967 | Level 2 | 4.1876 | 0.000261727 | 0.240175
2253236 | Level 2 | 0.251416 | 0.000445281 | 0.0188082
2253446 | Level 2 | 0.251416 | 0.000445281 | 0.0188082
2253465 | Level 2 | 0.251416 | 0.000445281 | 0.0188082
2253466 | Level 2 | 0.251416 | 0.000445281 | 0.0188082
2253986 | Level 2 | 0.2536 | 0.000261727 | 0.0145449
2253987 | Level 2 | 0.2536 | 0.000261727 | 0.0145449
2253988 | Level 2 | 0.2536 | 0.000261727 | 0.0145449
2253989 | Level 2 | 0.2536 | 0.000261727 | 0.0145449
2255175 | Level 2 | 0.489136 | 0.000261727 | 0.0280538
2256116 | Level 2 | 0.283132 | 0.000261727 | 0.0162387
2256158 | Level 2 | 0.313008 | 0.000261727 | 0.0179522
2256200 | Level 2 | 0.341514 | 0.000445281 | 0.0255484
2257870 | Level 2 | 0.49005 | 0.000261727 | 0.0281062
2257871 | Level 2 | 0.489925 | 0.000261727 | 0.028099
2257872 | Level 2 | 0.658633 | 0.000445281 | 0.0492718
2258412 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2258413 | Level 2 | 0.05 | 0.000261727 | 0.00286769
2258416 | Level 2 | 0.0101622 | 0.000261727 | 0.000582842
2258437 | Level 2 | 2.666 | 0.000261727 | 0.152905
2259181 | Level 2 | 0.294393 | 0.000445281 | 0.0220233
2259258 | Level 2 | 0.294393 | 0.000445281 | 0.0220233
2259267 | Level 2 | 0.266821 | 0.000261727 | 0.0153032
2259276 | Level 2 | 0.934609 | 0.000261727 | 0.0536033
2259285 | Level 2 | 0.934609 | 0.000261727 | 0.0536033
2259294 | Level 2 | 0.266821 | 0.000261727 | 0.0153032
2259303 | Level 2 | 0.236821 | 0.000261727 | 0.0135826
2259312 | Level 2 | 0.976172 | 0.000261727 | 0.0559871
2259321 | Level 2 | 0.976172 | 0.000261727 | 0.0559871
2259330 | Level 2 | 0.236821 | 0.000261727 | 0.0135826
2259604 | Level 2 | 2.57112 | 0.000445281 | 0.192344
2259701 | Level 2 | 0.242784 | 0.000261727 | 0.0139245
2259827 | Level 2 | 0.212908 | 0.000261727 | 0.0122111
2260988 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2260989 | Level 2 | 0.114746 | 0.000261727 | 0.0065811
2260990 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2261110 | Level 2 | 0.210426 | 0.000261727 | 0.0120687
2261225 | Level 2 | 0.210426 | 0.000261727 | 0.0120687
2261266 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2261267 | Level 2 | 0.114746 | 0.000261727 | 0.0065811
2261268 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2261407 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2261408 | Level 2 | 0.0572458 | 0.000261727 | 0.00328326
2261409 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2261414 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2261415 | Level 2 | 0.0572458 | 0.000261727 | 0.00328326
2261416 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2261587 | Level 2 | 0.268238 | 0.000261727 | 0.0153845
2261617 | Level 2 | 0.268238 | 0.000261727 | 0.0153845
2261908 | Level 2 | 0.298501 | 0.000445281 | 0.0223306
2261983 | Level 2 | 0.881519 | 0.000445281 | 0.0659457
2262273 | Level 2 | 0.0279871 | 0.000261727 | 0.00160516
2262274 | Level 2 | 0.325292 | 0.000261727 | 0.0186567
2262275 | Level 2 | 0.0279871 | 0.000261727 | 0.00160516
2262810 | Level 2 | 0.0532747 | 0.000261727 | 0.0030555
2264583 | Level 2 | 0.0157747 | 0.000261727 | 0.000904735
2264672 | Level 2 | 0.2536 | 0.000261727 | 0.0145449
2264673 | Level 2 | 0.2536 | 0.000261727 | 0.0145449
2264674 | Level 2 | 0.2536 | 0.000261727 | 0.0145449
2264675 | Level 2 | 0.2536 | 0.000261727 | 0.0145449
2266053 | Level 2 | 0.00269577 | 0.000445281 | 0.000201668
2266054 | Level 2 | 0.19699 | 0.000445281 | 0.0147367
2266057 | Level 2 | 0.00269577 | 0.000445281 | 0.000201668
2266115 | Level 2 | 0.201994 | 0.000445281 | 0.015111
2266270 | Level 2 | 0.0279871 | 0.000261727 | 0.00160516
2266271 | Level 2 | 0.0588525 | 0.000261727 | 0.00337541
2266272 | Level 2 | 0.0279871 | 0.000261727 | 0.00160516
2266392 | Level 2 | 0.0655463 | 0.000261727 | 0.00375932
2272212 | Level 2 | 0.00269577 | 0.000445281 | 0.000201668
2272213 | Level 2 | 0.0268968 | 0.000445281 | 0.00201213
2272216 | Level 2 | 0.00269577 | 0.000445281 | 0.000201668
2272333 | Level 2 | 0.00269577 | 0.000445281 | 0.000201668
2272334 | Level 2 | 0.0268968 | 0.000445281 | 0.00201213
2272337 | Level 2 | 0.00269577 | 0.000445281 | 0.000201668
2272479 | Level 2 | 0.881519 | 0.000445281 | 0.0659457
2272563 | Level 2 | 0.298501 | 0.000445281 | 0.0223306
2272734 | Level 2 | 0.0279871 | 0.000261727 | 0.00160516
2272735 | Level 2 | 0.162792 | 0.000261727 | 0.00933673
2272736 | Level 2 | 0.0279871 | 0.000261727 | 0.00160516
2273529 | Level 6 | 0.254571 | 0.000261727 | 0.0146006
2273530 | Level 6 | 0.0303402 | 0.000261727 | 0.00174012
2273531 | Level 6 | 0.636683 | 0.000261727 | 0.0365161
2273532 | Level 6 | 0.0303369 | 0.000261727 | 0.00173993
2273533 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2273534 | Level 6 | 0.125 | 0.000261727 | 0.00716921
2273537 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2273540 | Level 6 | 0.0399794 | 0.000261727 | 0.00229297
2273567 | Level 6 | 0.573041 | 0.000261727 | 0.032866
2273569 | Level 6 | 0.128792 | 0.000261727 | 0.0073867
2273570 | Level 6 | 0.00733381 | 0.000261727 | 0.000420621
2273571 | Level 6 | 0.0725 | 0.000261727 | 0.00415814
2273574 | Level 6 | 0.00450539 | 0.000261727 | 0.000258401
2273590 | Level 6 | 0.804569 | 0.000261727 | 0.046145
2273591 | Level 6 | 0.765057 | 0.000261727 | 0.0438789
2273592 | Level 6 | 0.014569 | 0.000261727 | 0.000835586
2273593 | Level 6 | 0.776126 | 0.000261727 | 0.0445137
2273594 | Level 6 | 0.00913791 | 0.000261727 | 0.000524093
2273595 | Level 6 | 0.197426 | 0.000261727 | 0.0113231
2273596 | Level 6 | 0.589 | 0.000261727 | 0.0337813
2273597 | Level 6 | 0.0271261 | 0.000261727 | 0.00155578
2273600 | Level 6 | 0.364346 | 0.000261727 | 0.0208966
2273607 | Level 6 | 0.044371 | 0.000261727 | 0.00254484
2273645 | Level 6 | 0.804572 | 0.000261727 | 0.0461452
2273671 | Level 6 | 1.04706 | 0.000261727 | 0.0600525
2273700 | Level 6 | 1.59457 | 0.000261727 | 0.0914544
2273726 | Level 6 | 1.07111 | 0.000261727 | 0.061432
2273727 | Level 6 | 1.15372 | 0.000261727 | 0.0661699
2273728 | Level 6 | 3.2319 | 0.000261727 | 0.185361
2273745 | Level 6 | 0.0775289 | 0.000261727 | 0.00444657
2273746 | Level 6 | 0.0115765 | 0.000261727 | 0.000663952
2273747 | Level 6 | 0.125 | 0.000261727 | 0.00716921
2285446 | Level 6 | 0.278619 | 0.000261727 | 0.0159798
2285447 | Level 6 | 0.254571 | 0.000261727 | 0.0146006
2285448 | Level 6 | 0.0214432 | 0.000261727 | 0.00122985
2285449 | Level 6 | 0.0168275 | 0.000261727 | 0.000965118
2285450 | Level 6 | 2.04171 | 0.000261727 | 0.1171
2285910 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2285912 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2285916 | Level 2 | 0.0451243 | 0.000261727 | 0.00258804
2285920 | Level 2 | 0.045 | 0.000261727 | 0.00258092
2285926 | Level 2 | 0.0125953 | 0.000445281 | 0.000942241
2285940 | Level 2 | 0.0469318 | 0.000261727 | 0.00269171
2285941 | Level 2 | 0.0469318 | 0.000261727 | 0.00269171
2285949 | Level 2 | 0.0451222 | 0.000445281 | 0.00337555
2285970 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2285971 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2285972 | Level 2 | 0.0451243 | 0.000261727 | 0.00258804
2285973 | Level 2 | 0.0451243 | 0.000445281 | 0.00337571
2285974 | Level 2 | 0.045 | 0.000261727 | 0.00258092
2285979 | Level 2 | 0.00269577 | 0.000445281 | 0.000201668
2286000 | Level 2 | 0.0186475 | 0.000261727 | 0.0010695
2286001 | Level 2 | 0.0186475 | 0.000261727 | 0.0010695
2286002 | Level 2 | 0.0451243 | 0.000261727 | 0.00258804
2286003 | Level 2 | 0.0451243 | 0.000445281 | 0.00337571
2286004 | Level 2 | 0.045 | 0.000261727 | 0.00258092
2286009 | Level 2 | 0.0168379 | 0.000445281 | 0.00125963
2286018 | Level 2 | 0.570865 | 0.000261727 | 0.0327412
2286020 | Level 2 | 0.570741 | 0.000261727 | 0.0327341
2286022 | Level 2 | 0.613633 | 0.000445281 | 0.0459054
2286042 | Nivel 1 | 0.171367 | 0.000261717 | 0.00982852
2286044 | Nivel 1 | 0.215425 | 0.000445281 | 0.0161158
2286046 | Nivel 1 | 0.625425 | 0.000445281 | 0.0467875
2286047 | Nivel 1 | 0.829978 | 0.000261727 | 0.0476023
2286050 | Nivel 1 | 1.0301 | 0.000261727 | 0.0590802
2286077 | Nivel 1 | 2.84466 | 0.000261727 | 0.163152
2286081 | Nivel 1 | 2.80487 | 0.000261727 | 0.16087
2286085 | Nivel 1 | 2.81461 | 0.000445281 | 0.210559
2286089 | Nivel 1 | 2.84962 | 0.000261727 | 0.163436
2286093 | Nivel 1 | 2.87235 | 0.000261727 | 0.16474
2286097 | Nivel 1 | 2.84568 | 0.000445281 | 0.212883
2286571 | Nivel 1 | 0.258057 | 0.000261727 | 0.0148005
2286572 | Nivel 1 | 0.258057 | 0.000261727 | 0.0148005
2286573 | Nivel 1 | 0.258057 | 0.000261727 | 0.0148005
2286574 | Nivel 1 | 0.233057 | 0.000261727 | 0.0133667
2286579 | Nivel 1 | 0.258057 | 0.000261727 | 0.0148005
2286580 | Nivel 1 | 0.258057 | 0.000261727 | 0.0148005
2286581 | Nivel 1 | 0.258057 | 0.000261727 | 0.0148005
2286582 | Nivel 1 | 0.213057 | 0.000261727 | 0.0122196
2286679 | Nivel 1 | 0.25285 | 0.000445281 | 0.0189155
2286680 | Nivel 1 | 0.25285 | 0.000445281 | 0.0189155
2286681 | Nivel 1 | 0.25285 | 0.000445281 | 0.0189155
2286682 | Nivel 1 | 0.25285 | 0.000445281 | 0.0189155
2286859 | Nivel 1 | 0.269062 | 0.000445281 | 0.0201283
2286927 | Nivel 1 | 1.26499 | 0.000445281 | 0.0946327
2286936 | Nivel 1 | 0.270105 | 0.000445281 | 0.0202063
2287037 | Nivel 1 | 0.423275 | 0.000445281 | 0.0316649
2287116 | Nivel 1 | 0.244596 | 0.000261727 | 0.0140285
2287180 | Nivel 1 | 0.466225 | 0.000261727 | 0.0267397
2287189 | Nivel 1 | 1.31294 | 0.000261727 | 0.0753018
2287198 | Nivel 1 | 0.246225 | 0.000261727 | 0.0141219
2287241 | Nivel 1 | 0.214512 | 0.000261727 | 0.0123031
2287242 | Nivel 1 | 0.498725 | 0.000261727 | 0.0286037
2287243 | Nivel 1 | 1.35044 | 0.000261727 | 0.0774526
2287244 | Nivel 1 | 0.217012 | 0.000261727 | 0.0124464
2287339 | Level 6 | 1.15457 | 0.000261727 | 0.0662188
2287340 | Level 6 | 0.296722 | 0.000261727 | 0.0170181
2287341 | Level 6 | 0.0169358 | 0.000261717 | 0.000971332
2287342 | Level 6 | 0.0169361 | 0.000261727 | 0.00097135
2287343 | Level 6 | 0.743652 | 0.000261727 | 0.0426512
2287348 | Level 6 | 0.0169361 | 0.000261727 | 0.00097135
2287351 | Level 6 | 0.804568 | 0.000261727 | 0.046145
2287352 | Level 6 | 0.804568 | 0.000261727 | 0.046145
2287353 | Level 6 | 0.767058 | 0.000261727 | 0.0439936
2288319 | Level 6 | 0.805 | 0.000261727 | 0.0461697
2288320 | Level 6 | 0.258138 | 0.000261727 | 0.0148052
2288321 | Level 6 | 0.188638 | 0.000261727 | 0.0108191
2288324 | Level 6 | 0.699324 | 0.000261727 | 0.0401088
2288327 | Level 6 | 0.00783877 | 0.000261727 | 0.000449583
2289103 | Level 6 | 0.048 | 0.000261727 | 0.00275298
2292998 | Level 6 | 0.254575 | 0.000261727 | 0.0146008
2292999 | Level 6 | 0.631374 | 0.000261727 | 0.0362116
2293000 | Level 6 | 0.0924514 | 0.000261717 | 0.00530243
2293003 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2293004 | Level 6 | 0.0234188 | 0.000261727 | 0.00134315
2293007 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2293010 | Level 6 | 0.14887 | 0.000261727 | 0.00853825
2293015 | Level 6 | 0.254567 | 0.000261727 | 0.0146004
2293016 | Level 6 | 0.0161328 | 0.000261727 | 0.000925277
2293054 | Level 6 | 0.254563 | 0.000261727 | 0.0146001
2293055 | Level 6 | 0.254569 | 0.000261727 | 0.0146005
2293056 | Level 6 | 0.941552 | 0.000261727 | 0.0540015
2293057 | Level 6 | 0.0968611 | 0.000261727 | 0.00555534
2293058 | Level 6 | 0.0205476 | 0.000261727 | 0.00117848
2294336 | Level 6 | 0.4481 | 0.000261727 | 0.0257002
2297795 | Level 6 | 0.254571 | 0.000261727 | 0.0146006
2297796 | Level 6 | 0.0303402 | 0.000261727 | 0.00174012
2297797 | Level 6 | 0.636683 | 0.000261727 | 0.0365161
2297798 | Level 6 | 0.0301287 | 0.000261727 | 0.001728
2297799 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2297800 | Level 6 | 0.125 | 0.000261727 | 0.00716921
2297803 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2297806 | Level 6 | 0.0399794 | 0.000261727 | 0.00229297
2300775 | Level 6 | 1.04706 | 0.000261727 | 0.0600526
2306320 | Level 6 | 0.804569 | 0.000261727 | 0.046145
2306321 | Level 6 | 0.765057 | 0.000261727 | 0.0438789
2306322 | Level 6 | 0.0128558 | 0.000261727 | 0.000737327
2306323 | Level 6 | 0.776126 | 0.000261727 | 0.0445137
2306324 | Level 6 | 0.00913791 | 0.000261727 | 0.000524093
2306327 | Level 6 | 0.187426 | 0.000261727 | 0.0107496
2306328 | Level 6 | 0.589 | 0.000261727 | 0.0337813
2306331 | Level 6 | 0.0221261 | 0.000261727 | 0.00126901
2306334 | Level 6 | 0.364346 | 0.000261727 | 0.0208966
2306345 | Level 6 | 0.804569 | 0.000261727 | 0.046145
2306348 | Level 6 | 0.0443704 | 0.000261727 | 0.0025448
2306355 | Level 6 | 0.120722 | 0.000261727 | 0.00692383
2312397 | Level 6 | 1.07706 | 0.000261727 | 0.0617732
2317143 | Level 6 | 1.07111 | 0.000261727 | 0.061432
2317144 | Level 6 | 0.481702 | 0.000261727 | 0.0276274
2317145 | Level 6 | 3.7544 | 0.000261727 | 0.215329
2317162 | Level 6 | 0.0810395 | 0.000261727 | 0.00464791
2317163 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2317164 | Level 6 | 0.125 | 0.000261727 | 0.00716921
2317965 | Level 6 | 0.254569 | 0.000261727 | 0.0146005
2317966 | Level 6 | 0.0229341 | 0.000261727 | 0.00131535
2317967 | Level 6 | 0.0183334 | 0.000261727 | 0.00105149
2317968 | Level 6 | 2.04219 | 0.000261727 | 0.117127
2319084 | Level 6 | 0.279115 | 0.000261717 | 0.0160083
2319554 | Level 6 | 1.15457 | 0.000261727 | 0.0662188
2319555 | Level 6 | 0.804569 | 0.000261727 | 0.046145
2319556 | Level 6 | 0.804569 | 0.000261727 | 0.046145
2319557 | Level 6 | 0.7926 | 0.000261727 | 0.0454585
2319558 | Level 6 | 0.296722 | 0.000261727 | 0.0170181
2319559 | Level 6 | 0.0229379 | 0.000261727 | 0.00131557
2319560 | Level 6 | 0.0229379 | 0.000261727 | 0.00131557
2319561 | Level 6 | 0.273138 | 0.000261727 | 0.0156655
2319564 | Level 6 | 0.201138 | 0.000261727 | 0.011536
2319565 | Level 6 | 0.684326 | 0.000261727 | 0.0392486
2319569 | Level 6 | 0.743669 | 0.000261727 | 0.0426522
2319576 | Level 6 | 0.0229379 | 0.000261727 | 0.00131557
2319581 | Level 6 | 0.00836907 | 0.000261727 | 0.000479997
2319588 | Level 6 | 0.767057 | 0.000261727 | 0.0439936
2325261 | Level 6 | 0.254569 | 0.000261727 | 0.0146005
2325262 | Level 6 | 0.254569 | 0.000261727 | 0.0146005
2325265 | Level 6 | 0.631383 | 0.000261727 | 0.0362121
2325266 | Level 6 | 0.941555 | 0.000261727 | 0.0540017
2325267 | Level 6 | 0.097445 | 0.000261727 | 0.00558883
2325268 | Level 6 | 0.0843352 | 0.000261727 | 0.00483694
2325269 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2325270 | Level 6 | 0.0234188 | 0.000261727 | 0.00134315
2325273 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2325276 | Level 6 | 0.14887 | 0.000261727 | 0.00853825
2325281 | Level 6 | 0.021137 | 0.000261727 | 0.00121229
2325290 | Level 6 | 0.00803087 | 0.000261727 | 0.0004606
2325549 | Level 6 | 0.254569 | 0.000261727 | 0.0146005
2325782 | Level 6 | 0.254569 | 0.000261727 | 0.0146005
2328996 | Level 6 | 0.0303424 | 0.000261727 | 0.00174025
2328997 | Level 6 | 0.636683 | 0.000261727 | 0.0365161
2328998 | Level 6 | 0.0301394 | 0.000261727 | 0.00172861
2328999 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2329000 | Level 6 | 0.125 | 0.000261727 | 0.00716921
2329003 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2329006 | Level 6 | 0.0399794 | 0.000261727 | 0.00229297
2329596 | Level 6 | 0.254573 | 0.000261727 | 0.0146007
2329661 | Level 6 | 0.217062 | 0.000261727 | 0.0124493
2331807 | Level 6 | 1.59457 | 0.000261727 | 0.0914544
2332557 | Level 6 | 1.04706 | 0.000261727 | 0.0600526
2333548 | Level 6 | 0.804569 | 0.000261727 | 0.046145
2333549 | Level 6 | 0.767057 | 0.000261727 | 0.0439936
2333550 | Level 6 | 0.0153557 | 0.000261717 | 0.000880709
2333551 | Level 6 | 0.778126 | 0.000261727 | 0.0446284
2333552 | Level 6 | 0.00913791 | 0.000261727 | 0.000524093
2333553 | Level 6 | 0.187426 | 0.000261727 | 0.0107496
2333554 | Level 6 | 0.589 | 0.000261727 | 0.0337813
2333555 | Level 6 | 0.0171261 | 0.000261727 | 0.000982244
2333558 | Level 6 | 0.36591 | 0.000261727 | 0.0209863
2333565 | Level 6 | 0.0443703 | 0.000261727 | 0.0025448
2333573 | Level 6 | 0.804569 | 0.000261727 | 0.046145
2335518 | Level 6 | 0.108949 | 0.000261727 | 0.00624865
2335809 | Level 6 | 1.07111 | 0.000261727 | 0.061432
2335810 | Level 6 | 0.856077 | 0.000261727 | 0.0490992
2335812 | Level 6 | 3.2344 | 0.000261727 | 0.185505
2335826 | Level 6 | 0.0755289 | 0.000261727 | 0.00433186
2335827 | Level 6 | 0.0144049 | 0.000261727 | 0.000826173
2335828 | Level 6 | 0.125 | 0.000261727 | 0.00716921
2365428 | Nivel 1 | 0.0469318 | 0.000261727 | 0.00269171
2365429 | Nivel 1 | 0.0469758 | 0.000261727 | 0.00269424
2365434 | Nivel 1 | 0.0451222 | 0.000445281 | 0.00337555
2366075 | Nivel 1 | 0.0568303 | 0.000261727 | 0.00325943
2366076 | Nivel 1 | 0.0550217 | 0.000445281 | 0.00411613
2367118 | Nivel 1 | 0.00522638 | 0.000261727 | 0.000299752
2367408 | Nivel 1 | 2.97681 | 0.000261717 | 0.170731
2367596 | Nivel 1 | 0.0144059 | 0.000261727 | 0.000826229
2367597 | Nivel 1 | 0.237501 | 0.000261727 | 0.0136215
2367600 | Nivel 1 | 0.00450587 | 0.000261727 | 0.000258428
2370972 | Nivel 1 | 0.0568313 | 0.000261727 | 0.00325948
2371076 | Nivel 1 | 0.170117 | 0.000261727 | 0.00975683
2371346 | Nivel 1 | 0.0257186 | 0.000261727 | 0.00147506
2371525 | Nivel 1 | 0.365689 | 0.000261727 | 0.0209736
2371699 | Nivel 1 | 0.00256568 | 0.000261727 | 0.000147152
2371911 | Nivel 1 | 0.185689 | 0.000261727 | 0.01065
2373153 | Nivel 1 | 0.0255161 | 0.000445281 | 0.00190884
2373160 | Nivel 1 | 0.273143 | 0.000445281 | 0.0204336
2373172 | Nivel 1 | 0.0255161 | 0.000445281 | 0.00190884
2373203 | Nivel 1 | 0.0531472 | 0.000445281 | 0.0039759
2373331 | Nivel 1 | 0.0255161 | 0.000445281 | 0.00190884
2373332 | Nivel 1 | 0.273143 | 0.000445281 | 0.0204336
2373335 | Nivel 1 | 0.0255161 | 0.000445281 | 0.00190884
2373341 | Nivel 1 | 0.0831472 | 0.000445281 | 0.00622018
2373585 | Nivel 1 | 0.05832 | 0.000261727 | 0.00334487
2373590 | Nivel 1 | 0.0277886 | 0.000261727 | 0.00159378
2373605 | Nivel 1 | 0.0751356 | 0.000261727 | 0.0043093
2373612 | Nivel 1 | 0.0277886 | 0.000261727 | 0.00159378
2373809 | Nivel 1 | 0.0277886 | 0.000261727 | 0.00159378
2373810 | Nivel 1 | 0.0751356 | 0.000261727 | 0.0043093
2373813 | Nivel 1 | 0.0277886 | 0.000261727 | 0.00159378
2373952 | Nivel 1 | 0.08832 | 0.000261727 | 0.00506548
2375528 | Nivel 1 | 1.01876 | 0.000261727 | 0.0584299
2375563 | Nivel 1 | 1.00604 | 0.000261727 | 0.0577001
2375597 | Nivel 1 | 0.98795 | 0.000445281 | 0.0739078
2375680 | Nivel 1 | 0.0535756 | 0.000261727 | 0.00307276
2375681 | Nivel 1 | 0.0535756 | 0.000261727 | 0.00307276
2375689 | Nivel 1 | 0.051206 | 0.000445281 | 0.00383068
2376947 | Nivel 1 | 0.0115765 | 0.000261727 | 0.000663952
2376948 | Nivel 1 | 3.3027 | 0.000261727 | 0.189422
2376955 | Nivel 1 | 0.0125953 | 0.000445281 | 0.000942241
2377555 | Nivel 1 | 0.0277886 | 0.000261727 | 0.00159378
2377556 | Nivel 1 | 0.195169 | 0.000261727 | 0.0111936
2378085 | Nivel 1 | 0.0115765 | 0.000261727 | 0.000663952
2378088 | Nivel 1 | 0.0277886 | 0.000261727 | 0.00159378
2378089 | Nivel 1 | 0.195169 | 0.000261727 | 0.0111936
2378124 | Nivel 1 | 1.15372 | 0.000261727 | 0.0661699
2378455 | Nivel 1 | 0.0288274 | 0.000445281 | 0.00215656
2378465 | Nivel 1 | 0.192491 | 0.000445281 | 0.0144001
2381040 | Level 6 | 2.58923 | 0.000445281 | 0.193698
2381533 | Level 6 | 0.171367 | 0.000261717 | 0.00982852
2381534 | Level 6 | 0.215425 | 0.000445281 | 0.0161158
2381535 | Level 6 | 0.625425 | 0.000445281 | 0.0467875
2381536 | Level 6 | 0.829978 | 0.000261727 | 0.0476023
2381537 | Level 6 | 1.0301 | 0.000261727 | 0.0590802
2381538 | Level 6 | 2.97193 | 0.000261727 | 0.170451
2381539 | Level 6 | 2.93214 | 0.000261727 | 0.168169
2381540 | Level 6 | 2.94188 | 0.000445281 | 0.22008
2381541 | Level 6 | 2.84962 | 0.000261727 | 0.163436
2381542 | Level 6 | 2.87235 | 0.000261727 | 0.16474
2381543 | Level 6 | 2.84568 | 0.000445281 | 0.212883
2381544 | Level 6 | 0.258057 | 0.000261727 | 0.0148005
2381545 | Level 6 | 0.258057 | 0.000261727 | 0.0148005
2381546 | Level 6 | 0.258057 | 0.000261727 | 0.0148005
2381547 | Level 6 | 0.233057 | 0.000261727 | 0.0133667
2381548 | Level 6 | 0.258057 | 0.000261727 | 0.0148005
2381549 | Level 6 | 0.258057 | 0.000261727 | 0.0148005
2381550 | Level 6 | 0.258057 | 0.000261727 | 0.0148005
2381551 | Level 6 | 0.213057 | 0.000261727 | 0.0122196
2381552 | Level 6 | 0.25285 | 0.000445281 | 0.0189155
2381553 | Level 6 | 0.25285 | 0.000445281 | 0.0189155
2381554 | Level 6 | 0.25285 | 0.000445281 | 0.0189155
2381555 | Level 6 | 0.25285 | 0.000445281 | 0.0189155
2381556 | Level 6 | 0.269062 | 0.000445281 | 0.0201283
2381557 | Level 6 | 1.26499 | 0.000445281 | 0.0946327
2381558 | Level 6 | 0.270105 | 0.000445281 | 0.0202063
2381559 | Level 6 | 0.623275 | 0.000445281 | 0.0466267
2381560 | Level 6 | 0.244596 | 0.000261727 | 0.0140285
2381561 | Level 6 | 0.666225 | 0.000261727 | 0.0382105
2381562 | Level 6 | 1.31294 | 0.000261727 | 0.0753018
2381563 | Level 6 | 0.246225 | 0.000261727 | 0.0141219
2381564 | Level 6 | 0.214512 | 0.000261727 | 0.0123031
2381565 | Level 6 | 0.698725 | 0.000261727 | 0.0400745
2381566 | Level 6 | 1.35044 | 0.000261727 | 0.0774526
2381567 | Level 6 | 0.217012 | 0.000261727 | 0.0124464
2381570 | Level 6 | 0.0469318 | 0.000261727 | 0.00269171
2381571 | Level 6 | 0.0469758 | 0.000261727 | 0.00269424
2381572 | Level 6 | 0.0451222 | 0.000445281 | 0.00337555
2381593 | Level 6 | 0.0568303 | 0.000261727 | 0.00325943
2381594 | Level 6 | 0.0550217 | 0.000445281 | 0.00411613
2381603 | Level 6 | 0.0568313 | 0.000261727 | 0.00325948
2381604 | Level 6 | 0.170117 | 0.000261727 | 0.00975683
2381607 | Level 6 | 0.0257186 | 0.000261727 | 0.00147506
2381608 | Level 6 | 0.365689 | 0.000261727 | 0.0209736
2381619 | Level 6 | 0.00256568 | 0.000261727 | 0.000147152
2381622 | Level 6 | 0.185689 | 0.000261727 | 0.01065
2381629 | Level 6 | 0.0255161 | 0.000445281 | 0.00190884
2381630 | Level 6 | 0.273143 | 0.000445281 | 0.0204336
2381633 | Level 6 | 0.0255161 | 0.000445281 | 0.00190884
2381636 | Level 6 | 0.0531472 | 0.000445281 | 0.0039759
2381637 | Level 6 | 0.0255161 | 0.000445281 | 0.00190884
2381638 | Level 6 | 0.273143 | 0.000445281 | 0.0204336
2381641 | Level 6 | 0.0255161 | 0.000445281 | 0.00190884
2381644 | Level 6 | 0.0831472 | 0.000445281 | 0.00622018
2381651 | Level 6 | 0.05832 | 0.000261727 | 0.00334487
2381652 | Level 6 | 0.0277886 | 0.000261727 | 0.00159378
2381653 | Level 6 | 0.0751356 | 0.000261727 | 0.0043093
2381656 | Level 6 | 0.0277886 | 0.000261727 | 0.00159378
2381663 | Level 6 | 0.0277886 | 0.000261727 | 0.00159378
2381664 | Level 6 | 0.0751356 | 0.000261727 | 0.0043093
2381667 | Level 6 | 0.0277886 | 0.000261727 | 0.00159378
2381670 | Level 6 | 0.08832 | 0.000261727 | 0.00506548
2381675 | Level 6 | 0.781701 | 0.000261727 | 0.0448334
2381676 | Level 6 | 0.768977 | 0.000261727 | 0.0441037
2381677 | Level 6 | 0.750888 | 0.000445281 | 0.0561733
2381678 | Level 6 | 0.0535756 | 0.000261727 | 0.00307276
2381679 | Level 6 | 0.0535756 | 0.000261727 | 0.00307276
2381680 | Level 6 | 0.051206 | 0.000445281 | 0.00383068
2381703 | Level 6 | 0.0115765 | 0.000261727 | 0.000663952
2381704 | Level 6 | 0.0125953 | 0.000445281 | 0.000942241
2381705 | Level 6 | 0.0277886 | 0.000261727 | 0.00159378
2381706 | Level 6 | 0.195169 | 0.000261727 | 0.0111936
2381715 | Level 6 | 0.0115765 | 0.000261727 | 0.000663952
2381716 | Level 6 | 0.0277886 | 0.000261727 | 0.00159378
2381717 | Level 6 | 0.195169 | 0.000261727 | 0.0111936
2381730 | Level 6 | 0.0288274 | 0.000445281 | 0.00215656
2381731 | Level 6 | 0.192491 | 0.000445281 | 0.0144001
2405933 | Level 2 | 0.61953 | 0.000677323 | 0.0571607
2406669 | Level 2 | 0.61953 | 0.000677323 | 0.0571607
2407273 | Level 2 | 0.0552726 | 0.000677323 | 0.00509971
2407364 | Level 2 | 0.0546969 | 0.000677323 | 0.00504659
2407369 | Level 2 | 0.67953 | 0.000677323 | 0.0626966
2408484 | Level 2 | 0.0594658 | 0.000677323 | 0.00548659
2408531 | Level 2 | 0.57953 | 0.000677323 | 0.0534701
2451193 | Level 2 | 0.0214587 | 0.000261727 | 0.00123074
2451210 | Level 2 | 0.695638 | 0.000261727 | 0.0398974
2451293 | Nivel 1 | 0.0315074 | 0.000261727 | 0.00180706
2451294 | Nivel 1 | 0.695638 | 0.000261727 | 0.0398974
2451315 | Level 6 | 0.0317126 | 0.000261727 | 0.00181884
2451316 | Level 6 | 0.695638 | 0.000261727 | 0.0398974
2452538 | Level 2 | 0.356806 | 0.000261727 | 0.0204642
2453111 | Nivel 1 | 0.356826 | 0.000261727 | 0.0204653
2455291 | Level 6 | 0.356971 | 0.000261727 | 0.0204736
2458923 | Level 2 | 0.0234812 | 0.000261727 | 0.00134673
2458924 | Level 2 | 0.695638 | 0.000261727 | 0.0398974
2458927 | Level 2 | 0.356919 | 0.000261727 | 0.0204706
2461155 | Level 2 | 0.0216761 | 0.000261727 | 0.0012432
2461156 | Level 2 | 0.695638 | 0.000261727 | 0.0398974
2461159 | Level 2 | 0.366426 | 0.000261717 | 0.0210159
2461164 | Level 2 | 0.0235107 | 0.000261727 | 0.00134843
2461165 | Level 2 | 0.695638 | 0.000261727 | 0.0398974
2461166 | Level 2 | 0.361543 | 0.000261727 | 0.0207358
2464332 | Level 2 | 1.59457 | 0.000261727 | 0.0914544
2468807 | Nivel 1 | 0.0314726 | 0.000261727 | 0.00180507
2468808 | Nivel 1 | 0.695638 | 0.000261727 | 0.0398974
2468811 | Nivel 1 | 0.356923 | 0.000261727 | 0.0204708
2470495 | Nivel 1 | 0.0316382 | 0.000261727 | 0.00181457
2470496 | Nivel 1 | 0.695638 | 0.000261727 | 0.0398974
2470499 | Nivel 1 | 0.356495 | 0.000261727 | 0.0204463
2470504 | Nivel 1 | 0.0315588 | 0.000261727 | 0.00181001
2470505 | Nivel 1 | 0.695638 | 0.000261727 | 0.0398974
2470506 | Nivel 1 | 0.356436 | 0.000261727 | 0.0204429
2475199 | Level 6 | 0.0314726 | 0.000261727 | 0.00180507
2475200 | Level 6 | 0.695638 | 0.000261727 | 0.0398974
2475203 | Level 6 | 0.35695 | 0.000261727 | 0.0204724
2478288 | Level 6 | 0.0316382 | 0.000261727 | 0.00181457
2478289 | Level 6 | 0.695638 | 0.000261727 | 0.0398974
2478292 | Level 6 | 0.356965 | 0.000261727 | 0.0204733
2478297 | Level 6 | 0.0315588 | 0.000261727 | 0.00181001
2478298 | Level 6 | 0.695638 | 0.000261727 | 0.0398974
2478299 | Level 6 | 0.356967 | 0.000261727 | 0.0204734
2486105 | Level 2 | 0.0334455 | 0.000261727 | 0.00191822
2486115 | Level 2 | 0.0770097 | 0.000261727 | 0.00441679
2488542 | Level 2 | 0.352514 | 0.000261727 | 0.020218
2488543 | Level 2 | 0.0475876 | 0.000261727 | 0.00272933
2488544 | Level 2 | 0.0259347 | 0.000261727 | 0.00148745
2491143 | Level 2 | 0.361767 | 0.000261727 | 0.0207487
2491144 | Level 2 | 0.0475876 | 0.000261727 | 0.00272933
2491145 | Level 2 | 0.0189955 | 0.000261727 | 0.00108946
2492793 | Level 2 | 0.282526 | 0.000261727 | 0.0162039
2492794 | Level 2 | 0.0475876 | 0.000261727 | 0.00272933
2492795 | Level 2 | 0.071715 | 0.000261727 | 0.00411312
2499900 | Nivel 1 | 0.279532 | 0.000261727 | 0.0160322
2499901 | Nivel 1 | 0.0475876 | 0.000261727 | 0.00272933
2499902 | Nivel 1 | 0.0363541 | 0.000261727 | 0.00208504
2502145 | Nivel 1 | 0.250299 | 0.000261727 | 0.0143556
2502146 | Nivel 1 | 0.0475876 | 0.000261727 | 0.00272933
2502147 | Nivel 1 | 0.0771443 | 0.000261727 | 0.00442451
2504818 | Nivel 1 | 0.269295 | 0.000261727 | 0.0154451
2504819 | Nivel 1 | 0.0475876 | 0.000261727 | 0.00272933
2504820 | Nivel 1 | 0.0581536 | 0.000261727 | 0.00333532
2507889 | Nivel 1 | 0.15765 | 0.000261727 | 0.00904183
2507890 | Nivel 1 | 0.0490018 | 0.000261727 | 0.00281044
2507891 | Nivel 1 | 0.081437 | 0.000261727 | 0.00467071
2511056 | Level 6 | 0.231314 | 0.000261727 | 0.0132667
2511057 | Level 6 | 0.0475876 | 0.000261727 | 0.00272933
2511058 | Level 6 | 0.084232 | 0.000261727 | 0.00483101
2511720 | Level 6 | 0.224028 | 0.000261727 | 0.0128489
2511721 | Level 6 | 0.0490018 | 0.000261727 | 0.00281044
2511722 | Level 6 | 0.0908775 | 0.000261727 | 0.00521216
2515386 | Level 6 | 0.282517 | 0.000261727 | 0.0162034
2515387 | Level 6 | 0.0475876 | 0.000261727 | 0.00272933
2515388 | Level 6 | 0.0446586 | 0.000261727 | 0.00256134
2516556 | Level 6 | 0.26221 | 0.000261727 | 0.0150387
2516557 | Level 6 | 0.0475876 | 0.000261727 | 0.00272933
2516558 | Level 6 | 0.0535812 | 0.000261727 | 0.00307308
2523800 | Level 2 | 13.9128 | 0.00113992 | 1.66528
2525000 | Level 2 | 0.100309 | 0.00113992 | 0.0120065
2525008 | Level 2 | 0.0706956 | 0.00113992 | 0.00846189
2525467 | Level 2 | 0.064716 | 0.000677323 | 0.005971
2525475 | Level 2 | 0.0745094 | 0.000677323 | 0.00687459
2525831 | Level 2 | 1.49977 | 0.000677323 | 0.138375
2525908 | Level 2 | 0.0747594 | 0.000677323 | 0.00689765
2525954 | Level 2 | 0.252355 | 0.000677323 | 0.0232834
2526634 | Level 2 | 1.49977 | 0.000677323 | 0.138375
2527715 | Level 2 | 0.0795094 | 0.000677323 | 0.00733591
2527813 | Level 2 | 0.213356 | 0.000677323 | 0.0196852
2528123 | Level 2 | 3.06717 | 0.000677323 | 0.282991
2530807 | Level 2 | 0.936752 | 0.00113992 | 0.112124
2532553 | Level 2 | 0.943321 | 0.000677323 | 0.0870352
2533057 | Level 2 | 0.901571 | 0.000677323 | 0.0831831
2533167 | Level 2 | 0.860821 | 0.000677323 | 0.0794233
2533462 | Level 2 | 5.34717 | 0.000677323 | 0.493354
2533855 | Level 2 | 2.9899 | 0.000677323 | 0.275862
2534001 | Level 2 | 1.51706 | 0.000261727 | 0.0870088
2534050 | Level 2 | 0.202183 | 0.000261727 | 0.011596
2563367 | Level 2 | 0.783715 | 0.000677323 | 0.0723092
2569924 | Level 2 | 1.06711 | 0.000261727 | 0.0612025
2573205 | Level 2 | 0.224401 | 0.000261727 | 0.0128702
2573206 | Level 2 | 0.0257186 | 0.000261727 | 0.00147506
2573209 | Level 2 | 0.3325 | 0.000261727 | 0.0190701
2573212 | Level 2 | 0.0257186 | 0.000261727 | 0.00147506
2575527 | Level 2 | 0.0257646 | 0.000261717 | 0.00147769
2575528 | Level 2 | 0.36 | 0.000261727 | 0.0206473
2575531 | Level 2 | 0.0257349 | 0.000261727 | 0.00147599
2575582 | Level 2 | 0.187708 | 0.000261727 | 0.0107658
2577521 | Level 2 | 0.178608 | 0.000261727 | 0.0102438
2577522 | Level 2 | 0.02798 | 0.000261727 | 0.00160476
2577525 | Level 2 | 0.325 | 0.000261727 | 0.01864
2577528 | Level 2 | 0.0279809 | 0.000261727 | 0.00160481
2577531 | Level 2 | 0.668654 | 0.000261727 | 0.0383498
2579376 | Nivel 1 | 0.817376 | 0.000261717 | 0.0468795
2579377 | Nivel 1 | 0.0045054 | 0.000261727 | 0.000258402
2579380 | Nivel 1 | 0.455819 | 0.000261727 | 0.0261429
2581084 | Level 6 | 0.62396 | 0.000261717 | 0.0357864
2581085 | Level 6 | 0.0257186 | 0.000261727 | 0.00147506
2581088 | Level 6 | 0.38 | 0.000261727 | 0.0217944
2581091 | Level 6 | 0.0257186 | 0.000261727 | 0.00147506
2581094 | Level 6 | 0.183113 | 0.000261717 | 0.0105022
2582899 | Nivel 1 | 0.221123 | 0.000261727 | 0.0126822
2582900 | Nivel 1 | 0.0242115 | 0.000261727 | 0.00138862
2582901 | Nivel 1 | 0.330327 | 0.000261727 | 0.0189455
2582904 | Nivel 1 | 0.024215 | 0.000261727 | 0.00138882
2582907 | Nivel 1 | 0.680212 | 0.000261727 | 0.0390127
2583136 | Level 6 | 0.216121 | 0.000261727 | 0.0123953
2583137 | Level 6 | 0.0280277 | 0.000261727 | 0.00160749
2583138 | Level 6 | 0.324927 | 0.000261727 | 0.0186357
2583141 | Level 6 | 0.0280334 | 0.000261727 | 0.00160782
2583144 | Level 6 | 0.680212 | 0.000261727 | 0.0390127
2587159 | Nivel 1 | 0.514375 | 0.000261717 | 0.0295013
2587168 | Nivel 1 | 0.0419308 | 0.000261727 | 0.00240488
2587185 | Nivel 1 | 0.184076 | 0.000261727 | 0.0105574
2587192 | Nivel 1 | 0.0724778 | 0.000261727 | 0.00415687
2587201 | Nivel 1 | 0.556051 | 0.000261727 | 0.0318916
2589526 | Level 6 | 0.17374 | 0.000261727 | 0.00996461
2589527 | Level 6 | 0.0279799 | 0.000261727 | 0.00160475
2589530 | Level 6 | 0.38 | 0.000261727 | 0.0217944
2589533 | Level 6 | 0.0279813 | 0.000261727 | 0.00160483
2589536 | Level 6 | 0.630081 | 0.000261727 | 0.0361375
2591304 | Level 6 | 0.221917 | 0.000261717 | 0.0127277
2591305 | Level 6 | 0.0257186 | 0.000261727 | 0.00147506
2591308 | Level 6 | 0.365 | 0.000261727 | 0.0209341
2591311 | Level 6 | 0.0257186 | 0.000261727 | 0.00147505
2591314 | Level 6 | 0.635168 | 0.000261727 | 0.0364292
2594024 | Nivel 1 | 0.538454 | 0.000261727 | 0.0308823
2594025 | Nivel 1 | 0.00450551 | 0.000261727 | 0.000258408
2594028 | Nivel 1 | 0.0825002 | 0.000261727 | 0.00473169
2594031 | Nivel 1 | 0.0327894 | 0.000261727 | 0.0018806
2594034 | Nivel 1 | 0.602073 | 0.000261727 | 0.0345311
2598847 | Level 2 | 0.722738 | 0.000261727 | 0.0414517
2598848 | Level 2 | 0.0356181 | 0.000261727 | 0.00204283
2598851 | Level 2 | 0.315205 | 0.000261727 | 0.0180782
2599003 | Level 2 | 1.14622 | 0.000261727 | 0.0657402
2599004 | Level 2 | 0.0327897 | 0.000261727 | 0.00188061
2599007 | Level 2 | 0.315205 | 0.000261727 | 0.0180782
2603447 | Level 2 | 0.735959 | 0.000261727 | 0.04221
2603448 | Level 2 | 0.0101622 | 0.000261727 | 0.000582842
2603451 | Level 2 | 0.05 | 0.000261727 | 0.00286769
2603454 | Level 2 | 0.0101622 | 0.000261727 | 0.000582842
2603457 | Level 2 | 0.284856 | 0.000261727 | 0.0163375
2605012 | Level 2 | 0.302037 | 0.000261727 | 0.0173229
2605013 | Level 2 | 0.0101622 | 0.000261727 | 0.000582842
2605016 | Level 2 | 0.05 | 0.000261727 | 0.00286769
2605019 | Level 2 | 0.0101622 | 0.000261727 | 0.000582842
2605022 | Level 2 | 0.763368 | 0.000261727 | 0.043782
2606636 | Level 2 | 0.180615 | 0.000261727 | 0.010359
2606637 | Level 2 | 0.0101622 | 0.000261727 | 0.000582842
2606640 | Level 2 | 0.05 | 0.000261727 | 0.00286769
2606643 | Level 2 | 0.0101622 | 0.000261727 | 0.000582842
2606646 | Level 2 | 0.835621 | 0.000261727 | 0.047926
2608270 | Level 2 | 0.762979 | 0.000261717 | 0.0437597
2608271 | Level 2 | 0.0101622 | 0.000261727 | 0.000582842
2608274 | Level 2 | 0.05 | 0.000261727 | 0.00286769
2608277 | Level 2 | 0.0101622 | 0.000261727 | 0.000582842
2608280 | Level 2 | 0.265879 | 0.000261727 | 0.0152492
2610503 | Nivel 1 | 0.737436 | 0.000261727 | 0.0422947
2610504 | Nivel 1 | 0.0101622 | 0.000261727 | 0.000582842
2610507 | Nivel 1 | 0.05 | 0.000261727 | 0.00286769
2610510 | Nivel 1 | 0.0101622 | 0.000261727 | 0.000582842
2610513 | Nivel 1 | 0.264814 | 0.000261727 | 0.0151881
2612436 | Nivel 1 | 0.737436 | 0.000261717 | 0.0422947
2612437 | Nivel 1 | 0.0101622 | 0.000261727 | 0.000582842
2612440 | Nivel 1 | 0.05 | 0.000261727 | 0.00286769
2612443 | Nivel 1 | 0.0101622 | 0.000261727 | 0.000582842
2612446 | Nivel 1 | 0.264814 | 0.000261727 | 0.0151881
2614477 | Nivel 1 | 0.253257 | 0.000261727 | 0.0145253
2614478 | Nivel 1 | 0.0101622 | 0.000261727 | 0.000582842
2614481 | Nivel 1 | 0.05 | 0.000261727 | 0.00286769
2614484 | Nivel 1 | 0.0101622 | 0.000261727 | 0.000582842
2614487 | Nivel 1 | 0.737436 | 0.000261727 | 0.0422947
2616171 | Nivel 1 | 0.0219966 | 0.000261727 | 0.00126159
2616183 | Nivel 1 | 1.07863 | 0.000261727 | 0.0618632
2616240 | Nivel 1 | 0.836436 | 0.000261727 | 0.0479727
2616314 | Nivel 1 | 0.163814 | 0.000261727 | 0.00939536
2616315 | Nivel 1 | 0.0115765 | 0.000261727 | 0.000663952
2616318 | Nivel 1 | 0.05 | 0.000261727 | 0.00286769
2616321 | Nivel 1 | 0.0115765 | 0.000261727 | 0.000663952
2619275 | Level 6 | 0.737436 | 0.000261717 | 0.0422947
2619276 | Level 6 | 0.0101622 | 0.000261727 | 0.000582842
2619279 | Level 6 | 0.05 | 0.000261727 | 0.00286769
2619282 | Level 6 | 0.0101622 | 0.000261727 | 0.000582842
2619285 | Level 6 | 0.253257 | 0.000261727 | 0.0145253
2619411 | Level 6 | 0.7342 | 0.000261717 | 0.0421091
2619412 | Level 6 | 0.0101622 | 0.000261727 | 0.000582842
2619415 | Level 6 | 0.05 | 0.000261727 | 0.00286769
2619418 | Level 6 | 0.0101622 | 0.000261727 | 0.000582842
2619421 | Level 6 | 0.268051 | 0.000261727 | 0.0153737
2619555 | Level 6 | 0.253257 | 0.000261727 | 0.0145253
2619556 | Level 6 | 0.0101622 | 0.000261727 | 0.000582842
2619559 | Level 6 | 0.05 | 0.000261727 | 0.00286769
2619562 | Level 6 | 0.0101622 | 0.000261727 | 0.000582842
2619565 | Level 6 | 0.737436 | 0.000261727 | 0.0422947
2619712 | Level 6 | 0.252258 | 0.000261727 | 0.0144679
2619713 | Level 6 | 0.0115765 | 0.000261727 | 0.000663952
2619716 | Level 6 | 0.05 | 0.000261727 | 0.00286769
2619719 | Level 6 | 0.0115765 | 0.000261727 | 0.000663952
2619722 | Level 6 | 0.736436 | 0.000261727 | 0.0422373
2619905 | Level 2 | 0.0415125 | 0.000261727 | 0.0023809
2619906 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2619909 | Level 2 | 0.05 | 0.000261727 | 0.00286769
2619912 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2619915 | Level 2 | 0.674593 | 0.000261727 | 0.0386904
2621446 | Level 2 | 0.00678818 | 0.000261717 | 0.000389327
2621447 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2621450 | Level 2 | 0.05 | 0.000261727 | 0.00286769
2621453 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2621456 | Level 2 | 0.686693 | 0.000261727 | 0.0393844
2623026 | Level 2 | 0.687196 | 0.000261727 | 0.0394132
2623027 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2623030 | Level 2 | 0.05 | 0.000261727 | 0.00286769
2623033 | Level 2 | 0.00450538 | 0.000261727 | 0.0002584
2623036 | Level 2 | 0.00651314 | 0.000261727 | 0.000373552
2624702 | Nivel 1 | 0.685939 | 0.000261727 | 0.0393411
2624703 | Nivel 1 | 0.00450199 | 0.000261727 | 0.000258206
2624706 | Nivel 1 | 0.0499976 | 0.000261727 | 0.00286755
2624709 | Nivel 1 | 0.00450368 | 0.000261727 | 0.000258303
2624712 | Nivel 1 | 0.0573411 | 0.000261727 | 0.00328872
2626123 | Nivel 1 | 0.686053 | 0.000261727 | 0.0393477
2626124 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
2626127 | Nivel 1 | 0.05 | 0.000261727 | 0.00286769
2626130 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
2626133 | Nivel 1 | 0.0455759 | 0.000261717 | 0.00261395
2627678 | Nivel 1 | 0.0480437 | 0.000261727 | 0.00275549
2627679 | Nivel 1 | 0.00450392 | 0.000261727 | 0.000258316
2627682 | Nivel 1 | 0.0499979 | 0.000261727 | 0.00286757
2627685 | Nivel 1 | 0.0045024 | 0.000261727 | 0.000258229
2627688 | Nivel 1 | 0.675021 | 0.000261727 | 0.038715
2629207 | Nivel 1 | 0.0518201 | 0.000261727 | 0.00297207
2629208 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
2629211 | Nivel 1 | 0.05 | 0.000261727 | 0.00286769
2629214 | Nivel 1 | 0.00450538 | 0.000261727 | 0.0002584
2629217 | Nivel 1 | 0.68655 | 0.000261727 | 0.0393762
2630927 | Level 6 | 0.686573 | 0.000261717 | 0.0393775
2630928 | Level 6 | 0.00450195 | 0.000261727 | 0.000258204
2630931 | Level 6 | 0.0499976 | 0.000261727 | 0.00286755
2630934 | Level 6 | 0.00450369 | 0.000261727 | 0.000258303
2630937 | Level 6 | 0.0535915 | 0.000261727 | 0.00307367
2633103 | Level 6 | 0.686551 | 0.000261727 | 0.0393763
2633104 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2633107 | Level 6 | 0.05 | 0.000261727 | 0.00286769
2633110 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2633113 | Level 6 | 0.0505761 | 0.000261727 | 0.00290072
2634667 | Level 6 | 0.0543354 | 0.000261727 | 0.00311634
2634668 | Level 6 | 0.00450374 | 0.000261727 | 0.000258306
2634671 | Level 6 | 0.0499977 | 0.000261727 | 0.00286755
2634674 | Level 6 | 0.0045021 | 0.000261727 | 0.000258212
2634677 | Level 6 | 0.686454 | 0.000261727 | 0.0393707
2636766 | Level 6 | 0.0306912 | 0.000261727 | 0.00176026
2636767 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2636770 | Level 6 | 0.05 | 0.000261727 | 0.00286769
2636773 | Level 6 | 0.00450538 | 0.000261727 | 0.0002584
2636776 | Level 6 | 0.708836 | 0.000261727 | 0.0406544
2638900 | Level 2 | 0.551273 | 0.000261727 | 0.0316176
2640685 | Level 2 | 0.0345125 | 0.000261727 | 0.00197942
2640700 | Level 2 | 0.0629116 | 0.000261727 | 0.00360821
2640707 | Level 2 | 0.0345125 | 0.000261727 | 0.00197942
2640716 | Level 2 | 0.342304 | 0.000261727 | 0.0196324
2641212 | Level 2 | 0.361995 | 0.000261727 | 0.0207618
2643919 | Level 2 | 0.368237 | 0.000261727 | 0.0211198
2646825 | Level 2 | 0.172289 | 0.000261727 | 0.00988144
2646828 | Level 2 | 0.0327897 | 0.000261727 | 0.00188061
2647869 | Level 2 | 0.0327897 | 0.000261727 | 0.00188061
2647872 | Level 2 | 0.0293131 | 0.000261727 | 0.00168121
2647964 | Level 2 | 0.172289 | 0.000261727 | 0.00988144
2647965 | Level 2 | 0.0327897 | 0.000261727 | 0.00188061
2647966 | Level 2 | 0.750419 | 0.000261727 | 0.0430393
2647969 | Level 2 | 0.0327897 | 0.000261727 | 0.00188061
2647970 | Level 2 | 0.0293131 | 0.000261727 | 0.00168121
2652582 | Level 2 | 1.18226 | 0.000261727 | 0.0678069
2652583 | Level 2 | 0.0327897 | 0.000261727 | 0.00188061
2652586 | Level 2 | 0.14375 | 0.000261727 | 0.00824459
2652589 | Level 2 | 0.0327897 | 0.000261727 | 0.00188061
2652592 | Level 2 | 0.0474988 | 0.000261727 | 0.00272423
2652651 | Level 2 | 0.760773 | 0.000261727 | 0.0436331
2652652 | Level 2 | 0.0327897 | 0.000261727 | 0.00188061
2652655 | Level 2 | 0.14375 | 0.000261727 | 0.00824459
2652658 | Level 2 | 0.0327897 | 0.000261727 | 0.00188061
2652661 | Level 2 | 0.0474988 | 0.000261727 | 0.00272423
2653520 | Level 2 | 0.0399439 | 0.000261727 | 0.00229093
2653534 | Level 2 | 0.778126 | 0.000261727 | 0.0446284
2653796 | Level 2 | 0.161932 | 0.000261727 | 0.0092874
2653801 | Level 2 | 0.0352294 | 0.000261727 | 0.00202054
2653811 | Level 2 | 0.062682 | 0.000261727 | 0.00359505
2653818 | Level 2 | 0.0352294 | 0.000261727 | 0.00202054
2653829 | Level 2 | 0.291841 | 0.000261727 | 0.0167382
2654370 | Level 2 | 0.130406 | 0.00155156 | 0.0182105
2654388 | Level 2 | 0.193925 | 0.00155156 | 0.0270804
2654395 | Level 2 | 0.130406 | 0.00155156 | 0.0182105
2654407 | Level 2 | 6.1574 | 0.00155156 | 0.859843
2654520 | Level 2 | 0.130406 | 0.00155156 | 0.0182105
2654523 | Level 2 | 0.193925 | 0.00155156 | 0.0270804
2654526 | Level 2 | 0.130406 | 0.00155156 | 0.0182105
2654953 | Level 2 | 1.00987 | 0.00155156 | 0.141022
2655100 | Level 2 | 1.14987 | 0.00155156 | 0.160572
2656402 | Level 2 | 0.134103 | 0.00242431 | 0.0234082
2656405 | Level 2 | 0.228116 | 0.00242431 | 0.0398188
2656408 | Level 2 | 0.134103 | 0.00242431 | 0.0234082
2656436 | Level 2 | 0.134103 | 0.00242431 | 0.0234082
2656439 | Level 2 | 0.228116 | 0.00242431 | 0.0398188
2656442 | Level 2 | 0.134103 | 0.00242431 | 0.0234082
2656490 | Level 2 | 1.35141 | 0.00242431 | 0.235895
2656658 | Level 2 | 1.27141 | 0.00242431 | 0.22193
2657687 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2657690 | Nivel 1 | 0.175 | 0.000261727 | 0.0100369
2657693 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2657696 | Nivel 1 | 0.0611205 | 0.000261727 | 0.00350548
2657903 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2657906 | Nivel 1 | 0.175 | 0.000261727 | 0.0100369
2657909 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2657912 | Nivel 1 | 0.0611205 | 0.000261727 | 0.00350548
2658839 | Nivel 1 | 0.0483648 | 0.000261727 | 0.0027739
2658840 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2658843 | Nivel 1 | 0.14625 | 0.000261727 | 0.00838798
2658846 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2658849 | Nivel 1 | 0.757407 | 0.000261727 | 0.0434401
2659135 | Nivel 1 | 0.0483648 | 0.000261727 | 0.0027739
2659136 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2659139 | Nivel 1 | 0.14625 | 0.000261727 | 0.00838798
2659142 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2659145 | Nivel 1 | 1.17889 | 0.000261727 | 0.0676139
2659886 | Nivel 1 | 1.17815 | 0.000261727 | 0.0675715
2659887 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2659890 | Nivel 1 | 0.145 | 0.000261727 | 0.00831629
2659893 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2659896 | Nivel 1 | 0.061911 | 0.000261727 | 0.00355082
2660094 | Nivel 1 | 0.756668 | 0.000261727 | 0.0433977
2660095 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2660098 | Nivel 1 | 0.145 | 0.000261727 | 0.00831629
2660101 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2660104 | Nivel 1 | 0.061911 | 0.000261727 | 0.00355082
2661358 | Nivel 1 | 0.0433648 | 0.000261727 | 0.00248713
2661359 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2661362 | Nivel 1 | 0.1675 | 0.000261727 | 0.00960674
2661365 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2661368 | Nivel 1 | 0.741157 | 0.000261727 | 0.0425081
2661384 | Nivel 1 | 0.0433648 | 0.000261727 | 0.00248713
2661385 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2661388 | Nivel 1 | 0.1675 | 0.000261727 | 0.00960674
2661391 | Nivel 1 | 0.0327897 | 0.000261727 | 0.00188061
2661394 | Nivel 1 | 1.16264 | 0.000261727 | 0.0666819
2663457 | Level 6 | 0.0567219 | 0.000261727 | 0.00325321
2663458 | Level 6 | 0.0356181 | 0.000261727 | 0.00204283
2663461 | Level 6 | 0.14875 | 0.000261727 | 0.00853136
2663464 | Level 6 | 0.0356181 | 0.000261727 | 0.00204283
2663467 | Level 6 | 1.17564 | 0.000261727 | 0.0674275
2663486 | Level 6 | 0.0566718 | 0.000261727 | 0.00325034
2663487 | Level 6 | 0.0356181 | 0.000261727 | 0.00204283
